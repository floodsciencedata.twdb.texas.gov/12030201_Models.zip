HEC-RAS study PIN OAK CREEK.prj: PIN OAK CREEK Base Level Engineering

--- PIN OAK CREEK.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,56660   ,776,776,776
BEGIN DESCRIPTION:
PIN OAK CREEK 90.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3602888.13      10647727.4      3605080.82     10646612.83
#Sta/Elev= 30
  3778.2  375.18  4223.3  358.68  4294.6  355.68  4449.7  353.23  4495.6  353.38
    4563   352.9  4676.2  352.51  4692.2  352.27    4958  353.18  5010.6  346.92
  5013.3  346.42  5016.6  346.92  5019.2  352.26    5025  353.85  5035.8  352.44
  5102.6  363.79  5258.3  369.96    5531  367.02  5547.6  363.17  5614.4  361.67
  5701.1  362.23  5747.9  362.81  5764.5  366.58  5770.1   363.2  5808.7  369.59
  5814.6     366  5843.9  373.23  5859.1  371.73  5888.8  375.84  6237.9  383.43
#Mann= 12 ,-1 , 0
  3778.2     .05       0  4223.3     .12       0  4294.6     .05       0
  4449.7     .12       0  4495.6     .05       0    4563     .12       0
  4676.2     .16       0  4692.2     .05       0  5010.6    .035       0
  5016.6     .05       0  5701.1     .08       0  5808.7     .05       0
Bank Sta=4958,5025
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55884   ,717,717,717
BEGIN DESCRIPTION:
PIN OAK CREEK 89.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603533.95     10648555.55       3604174.6     10647701.35
      3604789.15     10647237.83
#Sta/Elev= 30
  4033.2  362.69  4269.4  356.66  4304.8  354.53    4484  351.91    4534  348.88
  4913.1  350.35    4934  349.14  4940.2  350.33  4954.8  349.98  4969.4  347.35
    4984  338.35  4987.2  338.28    4990  337.78  4993.2  338.28  5004.8  344.28
    5034   350.2  5040.2  347.48  5048.6  349.06  5069.4  347.95  5098.5  350.38
  5126.9  348.96  5162.3  350.59  5247.7  350.74  5320.2  349.46  5341.3  346.23
  5347.6  349.41  5355.9  349.88  5533.1  354.77  5605.7  355.39  5870.7  365.78
#Mann= 3 ,-1 , 0
  4033.2     .05       0  4987.2     .03       0  4993.2     .05       0
Bank Sta=4940.2,5034
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55167   ,438,438,438
BEGIN DESCRIPTION:
PIN OAK CREEK 88.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603699.59      10648610.2      3604399.61     10648110.19
      3604749.64     10647910.17
#Sta/Elev= 30
  4154.8  364.35  4254.4  360.13  4319.5  355.58  4476.8  348.92  4607.1  349.54
  4707.8  347.57  4743.5   348.8    4929  349.65  4952.7  347.74  4978.2  344.84
  4986.8   342.8  4992.9  337.11  4998.5  336.52  5001.3  336.02  5004.5  336.52
  5007.7  341.34    5023  342.07  5028.7  344.73  5072.6  345.37    5082  344.36
  5087.8  346.65  5095.7   347.2  5103.6  345.87  5109.4  347.39  5125.2  344.07
  5130.9   348.3    5141   346.1  5153.3  350.41    5361  362.16  5418.2  365.23
#Mann= 5 ,-1 , 0
  4154.8     .05       0  4952.7     .12       0  4998.5     .07       0
  5004.5     .12       0    5361     .16       0
Bank Sta=4978.2,5028.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,54729   ,1012,1012,1012
BEGIN DESCRIPTION:
PIN OAK CREEK 87.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604597.62     10648963.01      3604692.82      10648160.6
       3604952.8     10647754.05
#Sta/Elev= 30
  4247.3  360.92  4421.3  351.84  4590.2  347.47  4602.6  345.38  4622.7  336.84
  4632.8   336.7    4642   344.5    4647  343.47  4652.9  345.84    4709  347.07
  4731.3   347.3  4874.5  346.92  4900.2  342.64  4914.8  344.82    4955   344.7
  4976.1  342.47  4987.9  340.19  4992.3  336.68  4995.1  336.18  4998.3  336.68
  5005.4  337.54  5015.5  343.02  5035.6  345.14  5090.6  352.74  5148.2  363.37
  5199.3  363.84  5312.8  364.17  5352.4  364.05  5479.1  365.82  5537.9  366.74
#Mann= 11 ,-1 , 0
  4247.3     .05       0  4590.2     .16       0    4709     .05       0
  4731.3     .16       0  4976.1     .12       0  4992.3     .07       0
  4998.3     .12       0  5199.3     .16       0  5312.8     .12       0
  5352.4     .16       0  5479.1     .12       0
Bank Sta=4955,5035.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,53717   ,721,721,721
BEGIN DESCRIPTION:
PIN OAK CREEK 86.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605054.81     10649112.86      3605023.57     10647754.32
#Sta/Elev= 30
  4622.1  364.95  4704.8  361.01  4764.8  354.16  4814.8  350.27  4824.8  348.59
  4874.8     349  4964.9  355.36  4974.9  348.56  4984.9   343.2  4991.9  333.04
  4994.6  332.54  4997.9  333.04  5004.9  333.28  5014.9  341.13  5023.6  342.17
  5034.9  342.57  5054.9  346.96  5234.9  346.55    5305  347.23    5325   346.1
    5345  347.39    5365  346.23    5385  347.98    5485  349.76    5515  353.78
    5545   356.1  5685.7  363.14  5755.1  366.12  5765.1  365.64    5981  367.88
#Mann= 5 ,-1 , 0
  4622.1     .05       0  4991.9     .03       0  4997.9     .05       0
  5023.6     .12       0  5685.7     .16       0
#XS Ineff= 2 , 0
          4915.8  352.13
Permanent Ineff=
       F       F
Bank Sta=4974.9,5054.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,52996   ,521,521,521
BEGIN DESCRIPTION:
PIN OAK CREEK 85.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605268.35     10649180.51      3605351.68      10648482.6
       3605424.6     10647466.98
#Sta/Elev= 30
  4376.4  365.95  4527.8   358.6  4628.5  350.23  4739.3  337.93  4799.7  338.22
  4829.9  341.79  4890.3  345.73  4930.4  346.82  4960.8  345.93  4968.6  344.97
    4981  338.87  4998.1  332.53  5000.9  332.03  5004.1  332.53  5011.2  335.95
  5017.9  342.23  5031.3  345.66  5041.4  345.75  5303.6  346.38  5401.6  351.84
  5452.6  353.61  5502.8  351.51  5522.8  352.74  5538.5  355.46  5543.5  352.73
    5593  360.31  5656.7  364.71  5923.8  370.45    5974  369.82  6097.5  373.06
#Mann= 7 ,-1 , 0
  4376.4     .05       0  4968.6     .12       0  4998.1     .07       0
  5004.1     .12       0  5303.6     .16       0  5401.6     .05       0
  5656.7     .16       0
Bank Sta=4960.8,5041.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,52475   ,150,150,150
BEGIN DESCRIPTION:
PIN OAK CREEK 84.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605149.72     10649668.86      3606441.36     10647460.57
#Sta/Elev= 30
  3649.9   370.5  3891.6  363.25  4190.7  360.68  4343.5  352.32  4431.2  340.98
  4474.2  341.47  4505.6  336.76  4511.4  341.06  4548.5  338.98  4671.7  352.84
  4923.3  342.84  4943.5  342.24  4970.8  334.44  4992.3  335.13  4999.2  330.42
    5002  329.92  5005.2  330.42  5045.2  342.33    5139  341.99  5264.2  346.23
  5301.4  343.01  5367.6   347.6  5393.9  348.05  5477.4   351.7  5548.3  361.32
  5600.5  360.92  5803.8  384.09  5884.3  386.27  6032.7  381.93  6208.2  392.04
#Mann= 7 ,-1 , 0
  3649.9     .05       0  4923.3     .16       0  4999.2     .07       0
  5005.2     .16       0    5139     .05       0  5367.6     .12       0
  5393.9     .05       0
#XS Ineff= 2 , 0
         4613.07  347.03
Permanent Ineff=
       F       F
Bank Sta=4943.5,5045.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,52325   ,751,751,751
BEGIN DESCRIPTION:
PIN OAK CREEK 83.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605264.29     10649726.17      3606587.21     10647549.09
#Sta/Elev= 30
  3656.3  365.77  3831.6  357.99  4137.8   353.7  4333.5  343.92  4364.5  345.04
  4370.3  342.42  4407.1  344.38  4428.5  340.73  4443.9  343.52  4449.8  340.52
  4480.7  341.61  4486.6  337.66  4523.4  342.51  4581.5  342.15  4618.4  349.36
    4692  353.39  4945.9  340.28    5001   330.2  5003.7   329.7    5007   330.2
  5040.8  341.33    5360  346.33  5450.1  356.02    5477  360.06  5514.2  358.42
  5600.9  366.58  5759.8  389.42  5891.6  391.84  6060.1  384.58  6203.8     396
#Mann= 5 ,-1 , 0
  3656.3     .05       0    5001     .04       0    5007     .05       0
  5450.1     .08       0  5514.2     .05       0
#XS Ineff= 2 , 0
         4665.91  354.54
Permanent Ineff=
       F       F
Bank Sta=4945.9,5040.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,51574   ,355,355,355
BEGIN DESCRIPTION:
PIN OAK CREEK 82.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605307.72     10649825.54       3606671.4     10648792.15
#Sta/Elev= 30
  3952.3  362.71  4071.3   357.5  4200.3  347.96  4335.5  340.68  4350.1  337.94
  4414.6   335.5  4707.5   335.6  4793.2  342.97  4843.1  343.48  4913.9  343.26
  4957.5  340.97  4963.8  342.46  4984.6  340.03  4993.9   334.9  4999.2  330.03
  5004.4  329.68  5007.2  329.18  5010.4  329.68  5013.7  334.43  5021.2  337.86
  5034.5     340  5178.1  343.81  5207.2  347.57  5235.5  346.51  5248.8  347.23
  5298.7  355.75  5352.5  352.52    5366  353.83  5542.1  379.51  5663.3  389.98
#Mann= 7 ,-1 , 0
  3952.3     .05       0  4993.9     .16       0  5004.4     .07       0
  5010.4     .16       0  5235.5     .05       0  5352.5     .08       0
    5366     .05       0
Bank Sta=4984.6,5034.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,51219   ,353,353,353
BEGIN DESCRIPTION:
PIN OAK CREEK 81.0
END DESCRIPTION:
XS GIS Cut Line= 3
       3605245.2     10650085.97      3606276.45     10649455.76
      3606771.24     10649117.22
#Sta/Elev= 30
  3900.8  361.94  4075.4  356.49  4105.2  353.71  4286.4  344.42  4361.8  337.06
  4381.2   335.5  4515.4   335.5  4686.9   335.5    4745   341.5  4787.6  342.65
  4831.8  346.15  4913.3  345.18  4961.8  340.46  4995.6  328.17  4998.3  327.67
  5001.6  328.17  5007.6  329.06  5019.9  337.54  5035.3  340.92  5050.8   343.3
  5056.6  341.61  5252.3   342.8  5288.2  345.28    5318  353.09  5380.9   349.9
  5431.7  354.38  5533.3  368.76  5554.3  370.16  5634.2  380.63  5708.9  385.46
#Mann= 5 ,-1 , 0
  3900.8     .05       0  4361.8     .16       0  4515.4     .05       0
  4995.6     .03       0  5001.6     .05       0
Bank Sta=4961.8,5035.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,50866   ,314,314,314
BEGIN DESCRIPTION:
PIN OAK CREEK 80.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605235.97     10650426.22      3607063.19     10649362.87
#Sta/Elev= 30
  3607.1  361.76  3709.1  359.24  3935.3  347.72  4120.3   335.5  4419.9   335.5
  4478.6  342.98  4601.9  351.11  4719.4  340.55  4725.2  337.27  4772.3  337.57
  4826.9  339.05  4879.9  345.85  4895.6  344.57  4907.2  340.38  4988.1  333.43
  5000.2  327.54  5002.9  327.04  5006.2  327.54  5011.3  329.03  5018.9  339.07
  5040.4  341.17  5114.9   345.2  5123.4  347.76  5200.9  350.94  5231.1  347.48
  5306.9  357.42  5345.9  362.17  5478.9   376.6  5559.2  379.84  5721.2   380.7
#Mann= 7 ,-1 , 0
  3607.1     .05       0  4772.3     .16       0  5000.2     .07       0
  5006.2     .16       0  5123.4     .05       0  5306.9     .08       0
  5345.9     .05       0
Bank Sta=4907.2,5040.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,50552   ,545,545,545
BEGIN DESCRIPTION:
PIN OAK CREEK 79.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605283.71     10650799.48      3607235.68     10649567.57
#Sta/Elev= 30
  3376.9  364.81  3387.4  366.17  3525.8  361.72  3779.2  344.95  3858.1  337.16
  3909.8   335.5    4317   335.5  4432.3  348.96  4532.3  351.41  4605.3  348.46
  4684.6  339.01  4799.6  337.53  4954.8  338.77  4997.1  330.55  5000.9  327.42
  5003.6  326.92  5006.9  327.42  5012.4  328.14  5027.5  338.71  5039.5  339.08
  5133.6  339.63  5157.6   341.3  5170.1  345.79  5210.5  346.24  5211.2  346.27
  5279.6  353.86  5352.5  365.26  5467.9  376.38    5562   379.7  5685.1  378.76
#Mann= 7 ,-1 , 0
  3376.9     .05       0  4799.6     .12       0  5000.9     .07       0
  5006.9     .12       0  5133.6     .05       0  5210.5     .08       0
  5211.2     .05       0
Bank Sta=4954.8,5039.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,50007   ,472,472,472
BEGIN DESCRIPTION:
PIN OAK CREEK 78.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605699.65     10651060.17      3606699.61     10650460.19
      3607249.62     10649860.18
#Sta/Elev= 30
  3812.1  361.47  3994.8  355.12  4286.3  348.16  4381.5  343.49  4476.8   335.5
  4544.1   335.5  4605.7   335.5  4768.3  335.58  4826.6  340.79  4912.2  339.61
  4943.3  340.83  4970.5  336.69  4975.3  332.91  4985.3   332.3  4996.5   328.8
  4999.3   328.3  5002.5   328.8    5063  338.66  5105.6   340.1    5113  339.58
  5119.8  342.09  5133.9  342.88  5148.1  341.08  5154.9  343.62    5204  343.76
  5211.6  342.39  5300.2  344.85  5381.8  347.85  5565.6  361.93  5792.2  374.66
#Mann= 7 ,-1 , 0
  3812.1     .05       0  4544.1      .1       0  4605.7     .05       0
  4996.5     .03       0  5002.5     .05       0    5204     .08       0
  5300.2     .05       0
Bank Sta=4943.3,5105.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,49535   ,319,319,319
BEGIN DESCRIPTION:
PIN OAK CREEK 77.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605846.46     10651351.44      3607685.73     10650440.49
#Sta/Elev= 30
  3980.6  359.43    4065  358.38    4118  355.06  4154.7  355.72  4226.2  347.32
  4238.4  347.11  4363.5  347.18  4418.3  352.66  4440.7  353.28  4530.4  349.41
  4642.5  352.23  4765.8  347.63  4821.1  348.38  4849.9  346.91  4917.2  339.61
  4990.1  329.78  4996.6  327.41  4999.4  326.91  5002.6  327.41  5021.9  331.35
  5051.7  332.74  5088.9  339.15    5119   342.4  5169.4  339.77  5320.8  339.16
  5455.4  349.24  5724.5  355.22  5870.2  362.09  5976.7  363.03  6033.1  361.43
#Mann= 5 ,-1 , 0
  3980.6     .05       0  4226.2     .08       0  4238.4     .05       0
  4996.6     .03       0  5002.6     .05       0
#XS Ineff= 2 , 0
                         5121.02          342.42
Permanent Ineff=
       F       F
Bank Sta=4917.2,5088.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,49216   ,436,436,436
BEGIN DESCRIPTION:
PIN OAK CREEK 76.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605950.63     10651737.73      3607772.86     10650674.76
#Sta/Elev= 30
  3870.3  356.05  4174.5  352.54  4291.9  347.25  4297.7  349.08  4313.4  349.33
  4334.9  346.97  4473.8  347.25  4526.7  351.28  4671.5  351.41  4773.2  349.35
  4810.4  351.73  4876.3  343.39  4906.3  337.81  4970.8  330.95  4992.3  330.04
  4999.2   326.8    5002   326.3  5005.2   326.8  5029.5  330.97  5045.2  330.18
  5088.2  337.83  5096.3  338.36  5109.7  342.31  5131.2  343.63  5323.1  337.82
  5360.3  338.93  5424.8  344.42  5696.9  348.02  5871.9  359.82  5979.9  360.48
#Mann= 3 ,-1 , 0
  3870.3     .05       0  4999.2     .03       0  5005.2     .05       0
#XS Ineff= 2 , 0
                         5200.28          341.87
Permanent Ineff=
       F       F
Bank Sta=4906.3,5088.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,48780   ,563,563,563
BEGIN DESCRIPTION:
PIN OAK CREEK 75.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605985.35     10652041.55      3607248.41       10651499.
       3607912.2     10650934.99
#Sta/Elev= 30
  3776.2  357.69  4075.6  353.77  4222.3  347.64  4655.4  347.32    4793  344.23
  4860.1  345.99  4901.8  341.29  4930.8  336.19  4945.4  335.18  4977.9     330
  4988.9  326.17  4996.8  325.26  4999.5  324.76  5002.8  325.26  5006.9  328.71
  5021.6  329.41  5059.4  334.74  5111.9  341.14  5119.5  343.14  5130.1  343.51
  5165.6  341.51  5342.4  337.51    5371  334.55  5406.1  334.52  5625.7  343.68
    5718  345.54  5832.3  350.37  5910.2   351.9  5966.2  355.63  6021.9   354.5
#Mann= 3 ,-1 , 0
  3776.2     .05       0  4996.8     .03       0  5002.8     .05       0
#XS Ineff= 2 , 0
                         5276.14          339.32
Permanent Ineff=
       F       F
Bank Sta=4945.4,5059.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,48217   ,498,498,498
BEGIN DESCRIPTION:
PIN OAK CREEK 74.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606358.64     10652314.97      3607534.87     10651967.75
      3609018.49     10651004.69
#Sta/Elev= 30
  3890.8  354.83  4280.7  351.54  4548.7   345.1  4590.4  340.08  4629.3  342.51
  4839.5  337.47  4861.5  339.54  4916.6  333.64  4976.2  327.32    4994  321.86
  4996.8  321.36    5000  321.86    5070  333.32  5088.3  336.33  5155.7  334.48
  5182.7  337.62    5213  334.43    5273  334.23  5400.2  331.03  5761.2  336.78
  6064.7  339.31  6100.9  341.94  6146.3   337.4  6390.9   337.4    6412   342.1
  6499.6   341.6  6725.4  357.43  6774.5  361.92  6808.7  359.12    6886   365.8
#Mann= 7 ,-1 , 0
  3890.8     .05       0    4994     .03       0    5000     .05       0
    5273     .16       0  5761.2     .05       0  6725.4     .08       0
  6808.7     .05       0
#XS Ineff= 2 , 0
                         5196.31          336.96
Permanent Ineff=
       F       F
Bank Sta=4916.6,5070
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,47719   ,301,301,301
BEGIN DESCRIPTION:
PIN OAK CREEK 73.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606688.48     10652466.88      3607539.21      10652501.6
       3609043.8     10651664.75
#Sta/Elev= 30
  4017.2  349.65    4465  338.76  4538.8   342.2  4648.9  334.01  4927.5  331.25
    4988  324.09    5000  321.78  5002.7  321.28    5006  321.78  5068.2  330.78
  5103.8  334.35  5171.1  334.21  5200.9  337.77  5327.5  328.97  5376.9  328.86
  5495.9  333.82  5604.5  334.44  5612.9  331.86  5642.3  334.27  5663.4  333.59
  5685.7  331.86  5835.9  331.86  6118.4  336.68  6162.6  337.35  6207.9  343.32
  6297.5   344.8  6365.2  348.67  6417.8  351.73  6487.4  355.57  6590.3   365.5
#Mann= 11 ,-1 , 0
  4017.2     .05       0    4988     .16       0    5000     .07       0
    5006     .16       0  5103.8     .05       0  5327.5     .16       0
  5663.4     .05       0  5835.9     .16       0  6118.4     .05       0
  6365.2     .08       0  6417.8     .05       0
#XS Ineff= 2 , 0
                          5237.5          334.08
Permanent Ineff=
       F       F
Bank Sta=4927.5,5068.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,47418   ,668,668,668
BEGIN DESCRIPTION:
PIN OAK CREEK 72.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3606560.85     10653128.38      3609371.66      10652144.6
#Sta/Elev= 30
  3668.3  349.05  4175.5  337.43  4920.8   328.2  4927.8  325.73  4982.8   323.6
  5005.6  319.74  5008.3  319.24  5011.6  319.74  5015.1  321.58    5028  323.89
  5065.3   323.4  5101.6  328.29  5163.7  336.66    5182  337.08  5225.8  325.82
  5277.2  328.69  5319.2  327.43  5514.9  331.13  5706.3  335.93  5799.4  331.96
  5943.9  332.61  5980.3  334.44  6029.6  340.69  6155.8  342.74  6326.3  355.11
  6503.1  372.16  6538.2  370.22  6559.4  374.43  6609.4  378.05  6646.3  380.88
#Mann= 9 ,-1 , 0
  3668.3     .05       0  5005.6     .03       0  5011.6     .05       0
  5015.1     .16       0    5028     .05       0  5319.2     .16       0
  5514.9     .05       0  6503.1     .08       0  6609.4     .05       0
#XS Ineff= 2 , 0
                         5200.28          333.13
Permanent Ineff=
       F       F
Bank Sta=4920.8,5101.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,46750   ,391,391,391
BEGIN DESCRIPTION:
PIN OAK CREEK 71.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606802.84     10653397.03       3608129.2     10653296.34
      3609479.85     10652525.53
#Sta/Elev= 30
  3780.1  344.74  4137.9  335.36  4569.1  331.05  4629.3  327.17  4829.9  327.17
  4849.9   330.5    4891  327.12  4940.2   321.4  4994.4  321.81  5007.4  318.72
  5010.1  318.22  5013.4  318.72  5020.4  321.31  5070.6   326.5  5097.2  332.11
    5108  335.73  5130.4  337.43  5173.6  333.83  5202.9  325.82  5576.8  325.82
  5641.6  332.95  5775.6  339.04  6001.7  331.14  6119.8  340.42  6259.5  345.79
  6566.2  368.23  6603.7  374.94  6625.3  375.74  6646.9  373.04  6665.4  374.46
#Mann= 5 ,-1 , 0
  3780.1     .05       0    4891     .16       0  5007.4     .07       0
  5013.4     .16       0  5097.2     .05       0
#XS Ineff= 2 , 0
         4850.28   330.5 5174.43          332.34
Permanent Ineff=
       F       F
Bank Sta=4891,5070.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,46359   ,455,455,455
BEGIN DESCRIPTION:
PIN OAK CREEK 70.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606709.04     10654213.02      3608250.73     10653629.67
      3609676.25     10653383.42
#Sta/Elev= 30
  3487.1  354.38  3605.3  350.59  3797.8  340.27  4047.6  333.76  4364.4  331.26
  4503.5  328.96  4514.1  327.17  4838.8  327.17  4856.3  329.66  4877.7  326.52
  4931.1  320.36  4984.6  321.57  5000.7   317.8  5003.5   317.3  5006.7   317.8
  5016.7  321.42  5039.2  320.75  5070.1  327.06  5102.2  335.87  5124.4  337.27
  5135.5   336.6  5174.9  325.82  5868.4  325.82  5915.7  334.73    5983  341.93
  6088.2  347.95    6294  355.72  6473.9  361.34  6580.6  368.85  6582.1  368.92
#Mann= 5 ,-1 , 0
  3487.1     .05       0  5000.7     .03       0  5006.7     .05       0
    6294     .16       0  6580.6     .05       0
#XS Ineff= 2 , 0
         4856.82  329.67 5147.73             332
Permanent Ineff=
       F       F
Bank Sta=4877.7,5070.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,45904   ,527,527,527
BEGIN DESCRIPTION:
PIN OAK CREEK 69.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607672.74     10654600.71      3608373.56     10653963.51
       3609735.7     10653706.28
#Sta/Elev= 30
    4265  347.74  4348.1  344.05  4390.6  344.57  4496.7  341.49  4581.9  341.98
  4645.4  337.93  4779.9  334.37  4836.6  327.17  4857.6  327.17    4865  329.74
  4893.4  331.36    4936  326.83  4971.1  320.04  4996.5  317.51  4999.2  317.01
  5002.5  317.51  5013.7  319.69  5070.4  320.36  5112.3  324.24  5154.9  325.94
  5197.5  335.71  5218.3  337.46  5248.9  333.62  5279.4  325.82  5742.2  325.82
  5778.1  330.67  6009.3  347.31  6185.1  355.91  6553.5  367.52  6598.4  370.19
#Mann= 3 ,-1 , 0
    4265     .05       0  4996.5     .03       0  5002.5     .05       0
#XS Ineff= 2 , 0
         4891.48  331.46 5252.84          332.17
Permanent Ineff=
       F       F
Bank Sta=4936,5154.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,45377   ,293,293,293
BEGIN DESCRIPTION:
PIN OAK CREEK 68.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3607805.62     10654815.89      3609736.21      10653853.2
#Sta/Elev= 30
    4062  348.03  4262.2  345.76  4314.5  345.79  4502.3  339.89  4576.9  340.57
  4688.8  336.13  4823.1   323.1  4873.4  327.74  4918.2  322.55  4979.7  318.24
  4985.3   312.8  4990.9  312.79  4993.7  312.29  4996.9  312.79  5002.1   312.8
  5007.7  317.34  5030.1   320.9  5046.9  320.47  5052.5  322.94    5142  337.51
  5181.2  337.74  5231.5  327.02  5253.9   326.7  5306.8  332.29  5432.9  335.56
  5597.3  345.44  5718.3  356.27  5897.3   365.7  6081.9  366.32  6219.3  369.87
#Mann= 5 ,-1 , 0
    4062     .05       0  4262.2     .08       0  4314.5     .05       0
  4990.9     .03       0  4996.9     .05       0
#XS Ineff= 2 , 0
         4869.32  327.72 5215.91          330.88
Permanent Ineff=
       F       F
Bank Sta=4918.2,5052.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,45084   ,407,407,407
BEGIN DESCRIPTION:
PIN OAK CREEK 67.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608349.59      10654760.2      3608899.61     10654510.19
      3609499.62     10654210.18
#Sta/Elev= 30
  4377.1  340.08  4414.5  339.32  4535.3   329.6  4640.7  318.09  4823.1  317.95
  4846.2  320.96  4851.7  323.51  4897.8  325.08  4915.4  319.35  4943.9  321.09
    4967  318.51  4972.5  312.26  4986.7  312.07  4989.4  311.57  4992.7  312.07
    5012  314.36  5017.6  318.51  5036.3  318.17  5050.8  318.85  5101.5  324.92
    5107  327.86  5149.1  331.25  5168.5  333.33  5174.1  336.61  5196.5  337.56
    5258  334.56  5383.8  347.47  5487.2  354.79  5540.3   361.8  5652.1  370.41
#Mann= 6 ,-1 , 0
  4377.1     .05       0  4986.7     .03       0  4992.7     .05       0
  5036.3     .16       0  5050.8     .08       0  5149.1     .05       0
Bank Sta=4897.8,5101.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,44677   ,368,368,368
BEGIN DESCRIPTION:
PIN OAK CREEK 66.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608149.59     10654910.19      3609249.61     10654710.19
      3609549.64     10654560.17
#Sta/Elev= 30
    3898  345.27  4009.8  342.37  4036.5  340.45    4142  339.53  4265.2  328.63
  4284.3  325.22  4345.2  317.95  4751.8  317.95  4772.1  319.79  4853.4  321.05
  4900.3  325.71  4930.9  321.48    4936  321.77  4989.4  316.48  4992.7   310.9
  4995.5   310.4  4998.7   310.9  5005.9  312.49  5013.5  319.29  5112.2   321.2
  5127.9  323.69  5141.8   327.2  5150.2  330.96  5172.6  329.97  5194.9  331.13
  5217.3   335.7  5225.7  338.59    5262  343.91  5315.1  355.12  5351.5  358.35
#Mann= 5 ,-1 , 0
    3898     .05       0  4900.3     .16       0  4992.7     .07       0
  4998.7     .16       0  5112.2     .05       0
Bank Sta=4936,5127.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,44309   ,503,503,503
BEGIN DESCRIPTION:
PIN OAK CREEK 65.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3608175.39     10655107.57      3610034.73     10655013.82
#Sta/Elev= 30
  3877.1  346.09  3951.4  346.07  4101.6  340.46  4151.7  335.68  4281.8  317.95
    4723  317.95  4782.5  320.66  4842.5  326.64  4872.6  325.85  4902.6  321.87
  4912.4  321.43  4915.3  322.93  4972.7  320.77  4992.7  318.08  4999.7  308.57
  5002.5  308.07  5005.7  308.57  5022.8  316.55  5032.8  319.18  5072.1  319.68
  5116.8  320.38  5122.9  322.12  5152.9   331.3    5183  328.72    5203  329.73
  5283.1  346.21  5343.2  354.06  5453.3     365  5593.5  374.58  5738.8  377.41
#Mann= 5 ,-1 , 0
  3877.1     .05       0  4915.3     .16       0  4999.7     .07       0
  5005.7     .16       0  5072.1     .05       0
Bank Sta=4972.7,5122.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,43806   ,397,397,397
BEGIN DESCRIPTION:
PIN OAK CREEK 64.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608628.43     10655640.09      3609291.65     10655395.29
      3609923.64     10655313.68
#Sta/Elev= 30
    4460   339.8  4738.9  322.68  4802.4  320.51  4844.6  323.91  4905.5  323.92
  4930.3  320.69  4966.3  319.11  4971.7   316.8  4983.6  314.76  4991.4  311.86
  4996.8  306.32  5001.9  306.26  5004.6  305.76  5007.9  306.26  5015.6  314.78
  5027.2  314.48  5058.2  318.87  5078.7  319.87  5100.8  320.98  5107.8   323.7
  5113.2  322.35  5163.2  331.92  5205.2  332.17  5235.5  328.23  5285.9  329.61
  5356.5   334.5  5427.1  342.42  5481.3  344.41    5635  363.11  5804.2  372.52
#Mann= 5 ,-1 , 0
    4460     .05       0  4971.7     .16       0  5001.9     .07       0
  5007.9     .16       0  5078.7     .05       0
#XS Ineff= 2 , 0
                         5219.09          330.74
Permanent Ineff=
       F       F
Bank Sta=4930.3,5100.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,43409   ,582,582,582
BEGIN DESCRIPTION:
PIN OAK CREEK 63.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3608883.41     10655818.92      3609944.11     10655820.66
#Sta/Elev= 30
  4734.6  336.39  4760.8   332.8  4790.8  330.65  4810.8  326.35  4846.7  324.63
  4860.8  324.85  4910.8  320.95  4945.7  319.86  4960.8  320.41  4990.8  306.45
  4997.8  306.39  5000.5  305.89  5003.8  306.39  5020.8  318.27  5050.8  320.13
  5090.8  319.37  5100.8  320.52  5140.3  330.97  5160.8  331.69  5190.8  330.85
  5220.8  327.88  5280.8  333.48  5330.8  340.19  5380.8  344.22  5450.8  353.72
  5480.8  359.18  5490.8  359.62  5580.8  370.44  5650.8  374.95  5795.3  376.96
#Mann= 6 ,-1 , 0
  4734.6     .05       0  4846.7     .16       0  4945.7     .12       0
  4997.8     .07       0  5003.8     .12       0  5140.3     .05       0
#XS Ineff= 2 , 0
                         5216.36          328.74
Permanent Ineff=
       F       F
Bank Sta=4960.8,5050.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,42827   ,434,434,434
BEGIN DESCRIPTION:
PIN OAK CREEK 62.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3608808.34     10655923.57      3609715.07     10656703.01
#Sta/Elev= 30
    4409   337.2  4450.5  333.55  4570.8  321.73    4613  318.97  4676.6   317.8
  4889.5  317.44  4960.8  319.02  4979.4  317.26  4981.7  316.95  4989.4   307.2
  5000.6  304.54  5003.4  304.04  5006.6  304.54  5010.2  305.94  5017.3  313.08
  5038.7  318.81    5053  319.04  5088.1  319.43  5095.8  322.94  5109.6  325.63
  5116.7  329.96  5130.9   329.6  5151.8   326.1  5208.8  338.08  5258.2  342.59
  5307.6  349.65  5372.3  354.35  5499.6  367.24    5549   369.1  5604.7  374.01
#Mann= 6 ,-1 , 0
    4409     .05       0  4450.5     .16       0  4570.8     .12       0
  4979.4     .05       0  5000.6     .03       0  5006.6     .05       0
Bank Sta=4960.8,5053
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,42393   ,406,406,406
BEGIN DESCRIPTION:
PIN OAK CREEK 61.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608749.59     10656010.15      3608999.61     10656610.19
      3609349.58     10656760.17
#Sta/Elev= 30
  4337.6  332.95  4396.3  328.43    4453  321.43  4529.9  318.31  4718.4  316.32
  4919.9  317.56  4949.2  315.71    4966  312.27    4973  310.37  4978.4  304.65
  4981.9  304.43  4984.7  303.93  4987.9  304.43  5009.4  307.45  5020.3  314.53
    5042  311.13  5049.3  312.14  5054.7  305.81  5072.9  309.84  5078.3  306.61
  5096.4  313.39  5107.3  310.27  5118.2  312.46  5125.5  316.57    5140  316.65
  5183.5  326.65  5198.5  324.93  5216.1  323.34  5292.3  338.33  5368.4  349.95
#Mann= 5 ,-1 , 0
  4337.6     .05       0  4396.3     .12       0  4981.9     .07       0
  4987.9     .12       0  5198.5     .05       0
#XS Ineff= 2 , 0
                          5197.5          324.91
Permanent Ineff=
       F       F
Bank Sta=4919.9,5125.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,41987   ,454,454,454
BEGIN DESCRIPTION:
PIN OAK CREEK 60.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608449.61     10656410.19      3609049.61     10656960.19
      3609299.58     10656960.19
#Sta/Elev= 30
  4165.9  326.74  4208.1  322.85  4215.5  320.79  4253.2  318.25  4413.5  316.47
  4618.8  315.85  4640.4  316.86  4661.3   315.8  4760.6  316.59  4781.6  318.94
  4795.8  317.09    4817  318.16  4852.5  316.06  4944.4  316.83    4966  316.47
  4972.7  308.88  4976.4  307.01  4982.3  307.01  4986.8  304.37  4989.6  303.87
  4992.8  304.37  5009.8  304.59  5029.8   315.7  5059.8  317.28  5086.5  324.77
  5089.8  325.68  5109.8  322.32  5119.8  323.39  5179.8  339.89  5229.8  348.99
#Mann= 5 ,-1 , 0
  4165.9     .05       0  4253.2     .12       0  4986.8     .07       0
  4992.8     .12       0  5086.5     .05       0
#XS Ineff= 2 , 0
                          5102.5          323.97
Permanent Ineff=
       F       F
Bank Sta=4944.4,5059.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,41533   ,438,438,438
BEGIN DESCRIPTION:
PIN OAK CREEK 59.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607899.57     10656860.17      3608899.61     10657360.19
      3609249.58     10657410.18
#Sta/Elev= 30
  3905.3  341.64  4008.8  335.43  4137.3  324.72  4187.6  326.39  4263.1  317.64
  4330.2  316.88    4428  314.94  4495.1  316.47  4713.9  315.31  4747.4  315.33
  4785.8     314  4821.7  315.12  4858.5  313.56  4942.3  315.49  4964.7  315.39
  4978.7  314.36    4998     302  5000.8   301.5    5004     302  5020.6  313.69
  5063.8  315.56    5084  316.34  5114.3  323.51    5121  323.34  5154.7  320.67
  5225.4  320.94  5235.5   322.9    5286  339.83  5346.6  351.31  5376.9  354.49
#Mann= 9 ,-1 , 0
  3905.3     .05       0  4330.2     .16       0  4713.9     .12       0
  4747.4     .16       0  4821.7     .12       0  4942.3     .16       0
    4998     .07       0    5004     .16       0    5121     .05       0
#XS Ineff= 2 , 0
                         5129.09          322.68
Permanent Ineff=
       F       F
Bank Sta=4964.7,5063.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,41095   ,431,431,431
BEGIN DESCRIPTION:
PIN OAK CREEK 58.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607549.64      10657460.2      3608749.61     10657760.19
      3609199.64     10657810.19
#Sta/Elev= 30
  3774.3  348.62  3790.6  347.27  3871.7   342.7  3928.9  341.15  3998.5  333.49
  4021.7  333.68  4155.7  322.32  4209.8   321.6    4269  315.42  4342.7  313.28
  4704.5  314.46  4874.5  312.97  4980.3  314.17  4993.2  302.12  4997.9  301.58
  5000.6  301.08  5003.9  301.58  5008.6  307.76  5013.7  307.76  5021.3  313.82
  5031.3  314.25  5082.3  313.64  5152.1  316.92  5182.3  323.78  5212.4  319.79
  5292.9  335.58  5323.1  338.49  5373.4  347.11  5403.6  349.46    5464   359.2
#Mann= 8 ,-1 , 0
  3774.3     .05       0  3790.6      .1       0  3871.7     .05       0
  4342.7     .12       0  4874.5     .16       0  4997.9     .07       0
  5003.9     .16       0  5082.3     .05       0
Bank Sta=4980.3,5031.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,40664   ,421,421,421
BEGIN DESCRIPTION:
PIN OAK CREEK 57.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607399.59     10657960.19      3608599.61     10658160.19
      3609149.57     10658110.19
#Sta/Elev= 30
  3796.7  356.83  3867.7  353.38  3958.9  341.83  4060.3  333.03  4090.7   328.5
  4121.1  329.71  4171.8  323.48  4344.2  313.39  4433.6  311.94  4536.8  313.33
  4597.6  311.37  4888.5  312.45  4952.4   311.5  4972.7  313.21    4993   301.2
  5000.1  301.03  5002.9  300.53  5006.1  301.03  5010.7  311.93  5043.4  313.41
  5111.1  312.04  5163.9  314.85  5204.1  321.19  5214.1  320.81  5224.1  315.45
  5254.3  315.45  5264.3  319.57  5314.5  325.13  5414.9  342.28  5565.5  360.99
#Mann= 6 ,-1 , 0
  3796.7     .05       0  4433.6     .12       0  4888.5     .16       0
  5000.1     .07       0  5006.1     .16       0  5111.1     .05       0
#XS Ineff= 2 , 0
                         5215.91          319.89
Permanent Ineff=
       F       F
Bank Sta=4972.7,5043.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,40243   ,418,418,418
BEGIN DESCRIPTION:
PIN OAK CREEK 56.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607849.57     10658360.18      3608449.61     10658560.19
      3609049.64     10658460.18
#Sta/Elev= 30
  4348.1  324.59  4485.2  312.84  4495.7  310.78  4510.4  311.57  4623.2  311.91
  4690.8  312.02  4716.3  312.02  4896.3     312  4917.3  310.76  4983.1  312.84
  4990.7  301.66  4997.9  301.57  5000.6  301.07  5003.9  301.57  5008.5  306.74
  5013.5   303.1  5021.1  312.28  5031.3  313.05  5149.5  312.59  5173.2  314.95
  5183.4  318.83  5203.6  319.74  5213.8  315.45  5386.1  315.45  5396.2  320.46
  5426.7  324.53  5467.2  333.52  5517.9  338.25  5555.9  344.21  5588.9  346.79
#Mann= 8 ,-1 , 0
  4348.1     .05       0  4510.4     .16       0  4623.2     .12       0
  4690.8     .05       0  4716.3     .16       0  4997.9     .07       0
  5003.9     .16       0  5149.5     .05       0
#XS Ineff= 2 , 0
                         5205.45          318.52
Permanent Ineff=
       F       F
Bank Sta=4983.1,5031.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,39825   ,738,738,738
BEGIN DESCRIPTION:
PIN OAK CREEK 55.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607749.59     10658360.17      3608349.61     10658960.19
      3608949.58     10659010.19
#Sta/Elev= 30
  4170.8   336.9  4255.7  328.14  4298.1  325.53    4383  317.95    4482  312.11
  4637.5  311.45  4679.9  309.94  4722.4  311.52  4788.5  310.56  4923.1  311.47
  4962.8  312.04  4976.9  311.36  4988.1  297.96  4990.8  297.46  4994.1  297.96
  5005.2  300.59  5015.8  312.06  5019.4  312.06  5129.7  310.98  5245.5  312.93
  5270.2  316.69  5280.3  316.69  5300.3  313.55  5322.9  312.95  5430.8   315.7
    5491  320.72  5521.1   319.8  5563.7  325.15  5591.3  332.93  5621.4   336.7
#Mann= 6 ,-1 , 0
  4170.8     .05       0  4788.5      .1       0  4923.1     .12       0
  4988.1     .07       0  4994.1     .12       0  5245.5     .05       0
#XS Ineff= 2 , 0
                         5283.52          316.35
Permanent Ineff=
       F       F
Bank Sta=4962.8,5019.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,39087   ,923,923,923
BEGIN DESCRIPTION:
PIN OAK CREEK 53.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607380.47     10659312.12      3607784.11     10659627.22
      3609109.59     10659668.88
#Sta/Elev= 30
  4140.2  331.61    4224  326.87  4358.8  314.42  4443.8   308.8  4522.5  309.38
  4586.7  307.87  4967.9  310.04  4984.9  297.54  4987.7  297.04  4990.9  297.54
  4997.9  298.48  5017.9   309.9    5028  310.47    5158  309.08  5215.9  310.72
  5223.6  314.63  5238.1  315.48  5258.1  312.58  5358.1  312.59  5398.1  321.48
  5412.9  320.81  5438.2  317.61  5508.2  317.54  5638.3  322.48  5709.3   329.4
  5735.9  332.08  5808.3   337.4  5898.4   346.9  5928.4  347.75  5978.4  346.19
#Mann= 7 ,-1 , 0
  4140.2     .05       0  4984.9     .03       0  4990.9     .05       0
  5215.9     .16       0  5412.9     .12       0  5709.3     .16       0
  5735.9     .05       0
#XS Ineff= 2 , 0
                         5253.41          313.65
Permanent Ineff=
       F       F
Bank Sta=4967.9,5028
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,38164   ,769,769,769
BEGIN DESCRIPTION:
PIN OAK CREEK 52.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3606074.62      10660158.9      3607093.06     10659990.72
      3608326.46     10660649.46      3608859.11     10660661.14
#Sta/Elev= 30
  2781.4  348.29  2818.9  346.84  3120.9  334.69  3437.2  318.29  3663.3  311.55
  3729.5  314.89  3785.5  310.59  4025.1  306.48    4732  306.64  4970.6   308.1
  4977.4  307.54  4986.8  302.98  4992.5  296.59  4997.1  294.93  4999.8  294.43
  5003.1  294.93  5014.5  298.15  5022.8  308.22  5104.2  307.92  5162.4  308.21
  5184.4  310.66  5192.8  314.95  5200.7  315.79    5216  315.36  5235.1  310.55
  5285.1  311.22  5575.2  329.86  5625.2  326.53  5685.2  332.24  5744.7  341.25
#Mann= 7 ,-1 , 0
  2781.4     .05       0  2818.9     .16       0  3437.2     .05       0
    4732     .12       0  4997.1     .07       0  5003.1     .12       0
  5104.2     .05       0
#XS Ineff= 2 , 0
         3703.12  312.53 5226.42          312.38
Permanent Ineff=
       F       F
Bank Sta=4970.6,5022.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,37395   ,544,544,544
BEGIN DESCRIPTION:
PIN OAK CREEK 51.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606499.57     10660410.17      3607699.61     10660910.19
      3608899.57     10661410.17
#Sta/Elev= 30
  3717.3  328.31  4031.5  308.43  4151.2   305.4  4789.8  304.65  4931.2  306.06
    4955  308.81  4978.9  306.48  4984.8   297.2  4992.7  295.21  4995.4  294.71
  4998.7  295.21  5026.5  306.79  5043.5  306.18    5132  306.35  5191.2  306.44
  5233.5  301.66  5238.9  303.83  5279.1  297.27  5297.8   295.7  5331.5  296.76
  5374.8  311.31  5392.7  312.66    5422  307.68  5894.8  307.68  5927.3  314.67
  6024.8   323.7  6066.5  320.26  6154.8   320.6  6219.8  324.91  6317.3  337.81
#Mann= 7 ,-1 , 0
  3717.3     .05       0  4992.7     .03       0  4998.7     .05       0
  5043.5     .12       0    5132     .05       0  5279.1     .08       0
  5297.8     .05       0
#XS Ineff= 2 , 0
                         5390.34          312.65
Permanent Ineff=
       F       F
Bank Sta=4955,5026.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,36851   ,510,510,510
BEGIN DESCRIPTION:
PIN OAK CREEK 50.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606039.78     10660529.52      3607489.46     10661328.15
      3608348.64     10662265.43
#Sta/Elev= 30
  3521.6  342.68  4089.7  314.98  4567.8  304.12    4743  304.88  4752.4  302.67
  4758.1  304.75  4765.9  297.15  4788.7  304.06  4926.6  299.61  4958.8  303.78
  4964.5  300.05  4980.6  302.02  4999.3  291.85  5002.1  291.35  5005.3  291.85
    5017  303.67  5024.1  305.99  5154.8  303.96  5668.3  306.34  5744.3  308.21
  5806.3  309.63  5884.7  311.49  6082.2  321.49  6165.6  324.11  6220.2   326.6
    6306  330.81  6332.2  330.02    6339  327.14  6358.1   331.2  6448.2  335.43
#Mann= 12 ,-1 , 0
  3521.6     .05       0  4999.3    .035       0  5005.3     .05       0
  5668.3     .16       0  5744.3     .12       0  5806.3     .16       0
  5884.7     .12       0  6082.2     .16       0  6165.6     .12       0
  6220.2     .16       0    6306     .12       0  6358.1     .05       0
Bank Sta=4958.8,5024.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,36341   ,705,705,705
BEGIN DESCRIPTION:
PIN OAK CREEK 49.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606126.66     10661371.56      3607376.62     10661597.25
      3607819.32     10662092.04
#Sta/Elev= 30
  4021.5  343.29  4101.1  342.63  4217.6  331.15  4300.8  326.55  4500.5  312.32
  4600.3  305.53  4700.2  303.63  4806.9  303.16  4817.1  296.02    4826  294.84
  4831.1  296.57  4837.4  303.24  4969.5  304.98  4979.7  304.87  4989.9  293.38
  4993.8  290.48  4996.6  289.98  4999.8  290.48  5010.2  292.46  5030.5  304.55
  5052.4  303.94  5172.8  303.29  5254.1  304.83  5309.7  303.59  5451.8  304.76
  5472.7   303.9  5669.8  307.82  5728.9  310.73  5942.5   323.5  5955.6  324.34
#Mann= 12 ,-1 , 0
  4021.5      .1       0  4101.1     .15       0  4300.8     .05       0
  4500.5      .1       0  4600.3     .16       0  4700.2     .12       0
  4993.8     .07       0  4999.8     .12       0  5052.4     .05       0
  5669.8     .16       0  5728.9     .12       0  5942.5     .16       0
Bank Sta=4969.5,5030.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,35636   ,577,577,577
BEGIN DESCRIPTION:
PIN OAK CREEK 48.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606499.56      10662060.2      3606899.61     10661960.19
      3607699.63     10662160.19
#Sta/Elev= 30
  4572.8  327.96  4719.7  315.04  4755.8  310.73  4838.3  305.04  4925.9  300.77
  4954.2  303.41    4962  301.61  4967.1  302.91  4974.8  300.14  4982.6  294.14
  4987.7  294.14  4992.5  289.95  4995.2  289.45  4998.5  289.95  5008.4  291.99
  5016.1  299.02  5026.4  303.53  5036.7  303.77  5067.6  303.14  5090.8  300.36
  5108.8  302.09  5126.9  300.36    5132  303.36  5162.2  302.57  5263.2  302.56
  5364.2   303.4  5428.4  303.02  5479.9  304.56  5613.9  310.06  5809.8  321.17
#Mann= 6 ,-1 , 0
  4572.8     .12       0  4992.5     .07       0  4998.5     .12       0
  5162.2     .07       0  5263.2     .05       0  5364.2     .16       0
Bank Sta=4954.2,5036.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,35059   ,582,582,582
BEGIN DESCRIPTION:
PIN OAK CREEK 47.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3606449.12     10662178.71      3607652.23     10663003.35
#Sta/Elev= 30
  4498.7  328.23  4543.6  325.66  4585.6   320.8  4641.1  316.48  4681.1  312.23
  4838.8  301.41  4896.3  299.68  4953.1  302.09    4960  302.05    4983  296.71
    4989  293.74  4993.4  288.18  4996.1  287.68  4999.4  288.18  5018.8  299.03
  5032.7  298.69  5054.7  301.94  5081.7  302.63  5204.3  300.87  5284.8   302.3
  5356.6  301.69  5377.6  303.26  5400.4  302.11  5420.7   303.2  5443.2  302.08
  5457.1  303.44  5464.2  301.99  5470.3  303.86  5756.2  310.22  5957.3  312.19
#Mann= 6 ,-1 , 0
  4498.7     .16       0  4641.1     .12       0  4993.4     .07       0
  4999.4     .12       0  5400.4     .05       0  5756.2     .12       0
Bank Sta=4953.1,5054.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,34477   ,717,717,717
BEGIN DESCRIPTION:
PIN OAK CREEK 46.0
END DESCRIPTION:
XS GIS Cut Line= 3
       3606199.6     10662460.18      3606549.61     10662760.19
      3607349.63      10663510.2
#Sta/Elev= 30
    4532  333.48  4535.3  333.48  4539.1  331.76    4560  330.21  4659.9  317.52
  4680.7  316.64  4737.5  310.95  4769.3  308.31    4830  303.73  4863.5  302.85
  4907.9  300.51    4965  301.28  4971.6  301.01  4979.3   298.1  4985.9  293.86
  4989.7  292.51  4996.4  292.51  5000.1  288.38  5003.9   288.1  5006.7   287.6
  5009.9   288.1  5028.4  301.91  5108.2  300.88  5141.7  299.74  5261.9  300.73
  5282.9  299.56  5339.6  299.77  5757.2  304.83  5912.5  309.88  6089.6  320.42
#Mann= 7 ,-1 , 0
    4532     .16       0  4737.5     .05       0  4769.3     .16       0
  4863.5     .12       0  5003.9     .07       0  5009.9     .12       0
  5108.2     .05       0
Bank Sta=4965,5028.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,33760   ,575,575,575
BEGIN DESCRIPTION:
PIN OAK CREEK 45.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606199.59     10662910.16      3606499.61     10663210.19
      3607199.64     10663660.21
#Sta/Elev= 30
    4577  320.37  4626.2  317.97  4803.3  301.73  4845.7  299.97  4908.8  300.25
  4958.9  300.46  4965.7  300.06    4973  299.64  4987.2  288.67  4994.8  286.67
  4997.5  286.17  5000.8  286.67  5004.3  286.67  5008.9   294.3  5014.8  297.72
  5024.1  299.82  5035.8  299.17  5051.2   297.9  5060.4  291.99  5066.4  290.73
  5081.5  297.79  5087.5  298.43  5150.5  299.57    5284  300.24  5513.4  303.16
  5804.7  315.76  5819.9  318.47  5825.9  320.57  5830.5  324.94  5833.5  324.94
#Mann= 10 ,-1 , 0
    4577     .16       0  4626.2     .12       0  4908.8     .16       0
  4965.7     .12       0  4994.8     .07       0  5000.8     .12       0
  5035.8     .16       0  5150.5     .05       0    5284     .16       0
  5513.4     .05       0
Bank Sta=4958.9,5024.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,33185   ,562,562,562
BEGIN DESCRIPTION:
PIN OAK CREEK 44.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605899.63     10662960.22      3606499.61     10663760.19
      3607049.64     10664060.21
#Sta/Elev= 30
    4015  321.56  4122.3  314.64  4236.8  309.55  4244.3  310.53  4257.7  311.67
  4286.3  310.04  4336.8  307.49  4357.7   304.4  4401.4   301.5  4507.7  298.46
  4636.8  298.43  4651.4  298.74  4657.7  300.27    4665  298.59  4693.1  298.29
  4951.4  299.43  4972.3  298.59  4978.5   293.6  4986.8  296.63  4993.1  286.09
  4998.4  285.76  5001.2  285.26  5004.4  285.76  5017.8  287.13    5023  290.53
  5044.9  296.94  5066.7  298.12  5088.5  298.06  5279.3  311.08  5641.5  340.83
#Mann= 5 ,-1 , 0
    4015     .05       0  4244.3     .16       0  4286.3     .12       0
  4998.4     .07       0  5004.4     .05       0
Bank Sta=4951.4,5066.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,32623   ,492,492,492
BEGIN DESCRIPTION:
PIN OAK CREEK 43.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605349.62      10663610.2      3606149.61     10664110.19
      3606949.58     10664360.18
#Sta/Elev= 30
  4085.5  323.73  4193.4  318.56  4349.5  306.56  4412.7  301.18  4534.2  297.01
  4564.8  297.39  4570.7  298.85  4592.6  297.07  4738.2  297.47  4768.9  294.42
    4796  296.75  4942.2  296.76  4969.9  298.04  4978.8     297  4984.7  294.55
  4993.5  286.82  5002.9  285.24  5005.6  284.74  5008.9  285.24  5015.3  286.08
  5021.2     293  5025.9  295.59  5045.1  297.57  5133.7  296.32  5322.2  299.96
  5468.9  305.53  5636.5  318.01  5688.9   323.7  5818.3  333.61    5867  339.31
#Mann= 4 ,-1 , 0
  4085.5     .12       0  4349.5     .05       0  5002.9     .03       0
  5008.9     .05       0
Bank Sta=4969.9,5045.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,32131   ,564,564,564
BEGIN DESCRIPTION:
PIN OAK CREEK 42.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605049.64     10663610.22      3605749.61     10664360.19
      3606549.58     10665160.16
#Sta/Elev= 30
  3966.8  337.52    4158  325.15    4391  312.74  4519.4  308.73  4532.7  309.15
    4561  307.45  4667.1  298.36  4745.2   295.5  4773.5   296.3  4865.4   296.7
  4886.4  295.61  4893.7   293.9  4900.6  294.77  4914.3  293.47  4964.6  297.07
  4978.7  296.59  4985.6  287.58  4986.2  284.35    4989  283.85  4992.2  284.35
  5006.8  286.36  5016.7  293.65  5020.9  296.74  5148.2  296.79  5233.1  295.35
  5431.1  299.86  5614.9     311  5784.6  324.64  5954.3   340.5    6124  354.57
#Mann= 7 ,-1 , 0
  3966.8     .12       0  4519.4     .05       0  4773.5     .16       0
  4914.3     .12       0  4986.2     .07       0  4992.2     .12       0
  5016.7     .05       0
Bank Sta=4964.6,5020.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,31567   ,805,805,805
BEGIN DESCRIPTION:
PIN OAK CREEK 41.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604599.63     10664010.21      3605399.61     10664710.19
      3606199.64     10665360.22
#Sta/Elev= 30
  3963.4  336.12  4076.8  321.17    4160  313.34    4233   308.2    4285  306.32
  4622.6  297.47  4679.5  295.31  4749.7  295.28  4930.9  295.28  4969.9  296.21
  4976.6  295.59  4990.8  284.39  4995.4  284.15  4998.1  283.65  5001.4  284.15
  5012.6  291.12  5019.3  290.93  5033.6   294.8  5083.1  292.94  5090.8  286.13
  5103.9  288.69    5111  293.62  5126.2  295.92  5140.6  293.84  5147.1  295.79
  5260.5  294.16  5559.4  300.97  5800.7   321.1    5851  328.84  6057.2  351.69
#Mann= 10 ,-1 , 0
  3963.4     .05       0    4160     .12       0    4233     .05       0
    4285     .12       0  4622.6     .16       0  4749.7     .05       0
  4930.9     .12       0  4995.4     .07       0  5001.4     .12       0
    5111     .05       0
Bank Sta=4969.9,5126.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,30762   ,575,575,575
BEGIN DESCRIPTION:
PIN OAK CREEK 40.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604499.58     10664160.15      3605049.61     10664960.19
      3605849.57     10665410.17
#Sta/Elev= 30
  3998.1  335.93  3998.6  335.93  4119.5  320.31  4283.9  304.76  4343.2  300.49
  4450.7  299.81  4588.1  294.78  4913.6   294.2    4969  295.34  4971.8  295.34
  4976.9  292.04  4982.7  285.15  4995.6   282.9  4998.4   282.4  5001.6   282.9
  5014.5  282.98  5020.3  286.47  5026.3  294.27  5036.2  295.31  5086.7  294.37
  5109.1  294.05  5365.8   294.2  5680.3  300.88  5754.6  304.09  5770.5  306.51
  5829.5  310.79  5857.2  314.63  5863.9  319.56  5878.9  320.51  5886.8  318.45
#Mann= 8 ,-1 , 0
  3998.1     .05       0  3998.6     .12       0  4283.9     .05       0
  4913.6     .07       0  4995.6     .07       0  5001.6     .07       0
  5086.7     .07       0  5109.1     .05       0
Bank Sta=4969,5036.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
