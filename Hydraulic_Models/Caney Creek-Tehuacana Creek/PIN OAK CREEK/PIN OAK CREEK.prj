HEC-RAS study PIN OAK CREEK.prj: PIN OAK CREEK Base Level Engineering

--- PIN OAK CREEK.g02 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,46750   ,391,391,391
BEGIN DESCRIPTION:
PIN OAK CREEK 71.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606802.84     10653397.03       3608129.2     10653296.34
      3609479.85     10652525.53
#Sta/Elev= 30
  3780.1  344.74  4137.9  335.36  4569.1  331.05  4629.3  327.17  4829.9  327.17
  4849.9   330.5    4891  327.12  4940.2   321.4  4994.4  321.81    4997  318.72
  4999.8  318.22    5003  318.72  5050.5  322.94  5097.2  332.11    5108  335.73
  5130.4  337.43  5173.6  333.83  5179.8  330.76  5202.9  325.82  5576.8  325.82
  5641.6  332.95  5775.6  339.04  6001.7  331.14  6119.8  340.42  6259.5  345.79
  6566.2  368.23  6603.7  374.94  6625.3  375.74  6646.9  373.04  6665.4  374.46
#Mann= 5 ,-1 , 0
  3780.1     .05       0    4891     .16       0    4997     .07       0
    5003     .16       0  5097.2     .05       0
#XS Ineff= 2 , 0
         4850.28   330.5 5174.43          332.34
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,46359   ,455,455,455
BEGIN DESCRIPTION:
PIN OAK CREEK 70.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606709.04     10654213.02      3608250.73     10653629.67
      3609676.25     10653383.42
#Sta/Elev= 30
  3487.1  354.38  3605.3  350.59  3797.8  340.27  4047.6  333.76  4364.4  331.26
  4503.5  328.96  4514.1  327.17  4838.8  327.17  4856.3  329.66  4931.1  320.36
  4984.6  321.57    4997   317.8  4999.8   317.3    5003   317.8  5009.1  318.04
  5016.7  321.42  5027.3  320.14  5048.7  321.85  5102.2  335.87  5124.4  337.27
  5135.5   336.6  5174.9  325.82  5868.4  325.82  5915.7  334.73    5983  341.93
  6088.2  347.95    6294  355.72  6473.9  361.34  6580.6  368.85  6582.1  368.92
#Mann= 5 ,-1 , 0
  3487.1     .05       0    4997     .03       0    5003     .05       0
    6294     .16       0  6580.6     .05       0
#XS Ineff= 2 , 0
         4856.82  329.67 5147.73             332
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,45904   ,527,527,527
BEGIN DESCRIPTION:
PIN OAK CREEK 69.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607672.74     10654600.71      3608373.56     10653963.51
       3609735.7     10653706.28
#Sta/Elev= 30
    4265  347.74  4348.1  344.05  4390.6  344.57  4496.7  341.49  4581.9  341.98
  4645.4  337.93  4779.9  334.37  4836.6  327.17  4857.6  327.17    4865  329.74
  4893.4  331.36    4936  326.83  4971.1  320.04    4997  317.51  4999.8  317.01
    5003  317.51  5013.7  319.69  5070.4  320.36  5112.3  324.24  5154.9  325.94
  5197.5  335.71  5218.3  337.46  5248.9  333.62  5279.4  325.82  5742.2  325.82
  5778.1  330.67  6009.3  347.31  6185.1  355.91  6553.5  367.52  6598.4  370.19
#Mann= 3 ,-1 , 0
    4265     .05       0    4997     .03       0    5003     .05       0
#XS Ineff= 2 , 0
         4891.48  331.46 5252.84          332.17
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,45377   ,293,293,293
BEGIN DESCRIPTION:
PIN OAK CREEK 68.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3607805.62     10654815.89      3609736.21      10653853.2
#Sta/Elev= 30
    4062  348.03  4262.2  345.76  4314.5  345.79  4688.8  336.13  4823.1   323.1
  4845.5  324.11  4851.1  327.27  4873.4  327.74  4979.7  318.24  4985.3   312.8
    4997  312.79  4999.8  312.29    5003  312.79  5007.7  317.34  5024.5  318.41
  5030.1   320.9  5046.9  320.47  5091.6  327.84  5097.2  331.09    5142  337.51
  5181.2  337.74  5231.5  327.02  5253.9   326.7  5306.8  332.29  5432.9  335.56
  5597.3  345.44  5718.3  356.27  5897.3   365.7  6081.9  366.32  6219.3  369.87
#Mann= 5 ,-1 , 0
    4062     .05       0  4262.2     .08       0  4314.5     .05       0
    4997     .03       0    5003     .05       0
#XS Ineff= 2 , 0
         4869.32  327.72 5215.91          330.88
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,45084   ,407,407,407
BEGIN DESCRIPTION:
PIN OAK CREEK 67.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608349.59      10654760.2      3608899.61     10654510.19
      3609499.62     10654210.18
#Sta/Elev= 30
  4377.1  340.08  4414.5  339.32  4535.3   329.6  4640.7  318.09  4823.1  317.95
  4851.7  323.51  4882.4  325.57  4897.8  325.08  4915.4  319.35  4943.9  321.09
    4967  318.51  4972.5  312.26    4997  312.07  4999.8  311.57    5003  312.07
    5012  314.36  5017.6  318.51  5036.3  318.17  5050.8  318.85  5101.5  324.92
    5107  327.86  5149.1  331.25  5168.5  333.33  5174.1  336.61  5196.5  337.56
    5258  334.56  5383.8  347.47  5487.2  354.79  5540.3   361.8  5652.1  370.41
#Mann= 6 ,-1 , 0
  4377.1     .05       0    4997     .03       0    5003     .05       0
  5036.3     .16       0  5050.8     .08       0  5149.1     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,44677   ,368,368,368
BEGIN DESCRIPTION:
PIN OAK CREEK 66.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608149.59     10654910.19      3609249.61     10654710.19
      3609549.64     10654560.17
#Sta/Elev= 30
    3898  345.27  4009.8  342.37  4036.5  340.45    4142  339.53  4265.2  328.63
  4284.3  325.22  4345.2  317.95  4751.8  317.95  4772.1  319.79  4853.4  321.05
  4900.3  325.71  4924.6  323.72  4930.9  321.48  4944.9  321.46  4989.4  316.48
  4995.7   310.9    4997   310.9  4999.8   310.4    5003   310.9  5013.5  319.29
  5112.2   321.2  5119.5  321.56  5141.8   327.2  5150.2  330.96  5172.6  329.97
  5194.9  331.13  5225.7  338.59    5262  343.91  5315.1  355.12  5351.5  358.35
#Mann= 5 ,-1 , 0
    3898     .05       0  4900.3     .16       0    4997     .07       0
    5003     .16       0  5112.2     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,44309   ,503,503,503
BEGIN DESCRIPTION:
PIN OAK CREEK 65.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3608175.39     10655107.57      3610034.73     10655013.82
#Sta/Elev= 30
  3877.1  346.09  3951.4  346.07  4101.6  340.46  4151.7  335.68  4281.8  317.95
    4723  317.95  4782.5  320.66  4842.5  326.64  4872.6  325.85  4902.6  321.87
  4912.4  321.43  4915.3  322.93  4917.4  324.02  4972.7  320.77  4992.7  318.08
    4997  308.57  4999.8  308.07    5003  308.57  5032.8  319.18  5072.1  319.68
  5111.8  321.41  5116.8  320.38  5152.9   331.3    5183  328.72    5203  329.73
  5283.1  346.21  5343.2  354.06  5453.3     365  5593.5  374.58  5738.8  377.41
#Mann= 5 ,-1 , 0
  3877.1     .05       0  4915.3     .16       0    4997     .07       0
    5003     .16       0  5072.1     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,43806   ,397,397,397
BEGIN DESCRIPTION:
PIN OAK CREEK 64.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608628.43     10655640.09      3609291.65     10655395.29
      3609923.64     10655313.68
#Sta/Elev= 30
    4460   339.8  4738.9  322.68  4802.4  320.51  4844.6  323.91  4910.8  323.81
  4930.3  320.69  4966.3  319.11  4971.7   316.8  4991.4  311.86    4997  306.26
  4999.8  305.76    5003  306.26  5004.9  306.26  5015.6  314.78  5027.2  314.48
  5058.2  318.87  5078.7  319.87  5100.8  320.98  5107.8   323.7  5113.2  322.35
  5138.3  328.17  5163.2  331.92  5205.2  332.17  5235.5  328.23  5285.9  329.61
  5356.5   334.5  5427.1  342.42  5481.3  344.41    5635  363.11  5804.2  372.52
#Mann= 5 ,-1 , 0
    4460     .05       0  4971.7     .16       0    4997     .07       0
    5003     .16       0  5078.7     .05       0
#XS Ineff= 2 , 0
                         5219.09          330.74
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,43409   ,582,582,582
BEGIN DESCRIPTION:
PIN OAK CREEK 63.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3608883.41     10655818.92      3609944.11     10655820.66
#Sta/Elev= 30
  4734.6  336.39  4760.8   332.8  4790.8  330.65  4810.8  326.35  4846.7  324.63
  4860.8  324.85  4910.8  320.95  4945.7  319.86  4960.8  320.41  4990.8  306.45
    4997  306.39  4999.8  305.89    5003  306.39  5020.8  318.27  5050.8  320.13
  5090.8  319.37  5110.8  322.76  5140.3  330.97  5160.8  331.69  5190.8  330.85
  5220.8  327.88  5280.8  333.48  5330.8  340.19  5380.8  344.22  5450.8  353.72
  5480.8  359.18  5490.8  359.62  5580.8  370.44  5650.8  374.95  5795.3  376.96
#Mann= 6 ,-1 , 0
  4734.6     .05       0  4846.7     .16       0  4945.7     .12       0
    4997     .07       0    5003     .12       0  5140.3     .05       0
#XS Ineff= 2 , 0
                         5216.36          328.74
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,42827   ,434,434,434
BEGIN DESCRIPTION:
PIN OAK CREEK 62.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3608808.34     10655923.57      3609715.07     10656703.01
#Sta/Elev= 30
    4409   337.2  4450.5  333.55  4570.8  321.73    4613  318.97  4676.6   317.8
  4889.5  317.44  4960.8  319.02  4979.4  317.26  4981.7  316.95  4989.4   307.2
    4997  304.54  4999.8  304.04    5003  304.54  5010.2  305.94  5017.3  313.08
  5031.1  317.34  5038.7  318.81  5088.1  319.43  5095.8  322.94  5109.6  325.63
  5116.7  329.96  5130.9   329.6  5151.8   326.1  5208.8  338.08  5258.2  342.59
  5307.6  349.65  5372.3  354.35  5499.6  367.24    5549   369.1  5604.7  374.01
#Mann= 6 ,-1 , 0
    4409     .05       0  4450.5     .16       0  4570.8     .12       0
  4979.4     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,42393   ,406,406,406
BEGIN DESCRIPTION:
PIN OAK CREEK 61.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608749.59     10656010.15      3608999.61     10656610.19
      3609349.58     10656760.17
#Sta/Elev= 30
  4337.6  332.95  4396.3  328.43    4453  321.43  4529.9  318.31  4718.4  316.32
  4919.9  317.56  4949.2  315.71    4973  310.37  4978.4  304.65    4997  304.43
  4999.8  303.93    5003  304.43  5020.3  314.53    5042  311.13  5049.3  312.14
  5054.7  305.81  5063.8  309.11  5072.9  309.84  5078.3  306.61  5096.4  313.39
  5107.3  310.27  5118.2  312.46  5125.5  316.57  5130.9  315.39    5140  316.65
  5183.5  326.65  5198.5  324.93  5216.1  323.34  5292.3  338.33  5368.4  349.95
#Mann= 5 ,-1 , 0
  4337.6     .05       0  4396.3     .12       0    4997     .07       0
    5003     .12       0  5198.5     .05       0
#XS Ineff= 2 , 0
                          5197.5          324.91
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,41987   ,454,454,454
BEGIN DESCRIPTION:
PIN OAK CREEK 60.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608449.61     10656410.19      3609049.61     10656960.19
      3609299.58     10656960.19
#Sta/Elev= 30
  4165.9  326.74  4208.1  322.85  4215.5  320.79  4253.2  318.25  4413.5  316.47
  4618.8  315.85  4640.4  316.86  4661.3   315.8  4760.6  316.59  4781.6  318.94
  4795.8  317.09    4817  318.16  4852.5  316.06  4958.6  316.62    4966  316.47
  4972.7  308.88  4976.4  307.01  4989.8  304.37    4997  304.37  4999.8  303.87
    5003  304.37  5009.8  304.59  5029.8   315.7  5059.8  317.28  5086.5  324.77
  5089.8  325.68  5109.8  322.32  5119.8  323.39  5179.8  339.89  5229.8  348.99
#Mann= 5 ,-1 , 0
  4165.9     .05       0  4253.2     .12       0    4997     .07       0
    5003     .12       0  5086.5     .05       0
#XS Ineff= 2 , 0
                          5102.5          323.97
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,41533   ,438,438,438
BEGIN DESCRIPTION:
PIN OAK CREEK 59.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607899.57     10656860.17      3608899.61     10657360.19
      3609249.58     10657410.18
#Sta/Elev= 30
  3905.3  341.64  4008.8  335.43  4137.3  324.72  4187.6  326.39  4263.1  317.64
  4330.2  316.88    4428  314.94  4495.1  316.47  4713.9  315.31  4747.4  315.33
  4785.8     314  4821.7  315.12  4858.5  313.56  4942.3  315.49  4978.7  314.36
    4987  310.13    4997     302  4999.8   301.5    5003     302  5009.4     305
  5020.6  313.69  5073.9  315.32  5114.3  323.51    5121  323.34  5154.7  320.67
  5225.4  320.94  5235.5   322.9    5286  339.83  5346.6  351.31  5376.9  354.49
#Mann= 9 ,-1 , 0
  3905.3     .05       0  4330.2     .16       0  4713.9     .12       0
  4747.4     .16       0  4821.7     .12       0  4942.3     .16       0
    4997     .07       0    5003     .16       0    5121     .05       0
#XS Ineff= 2 , 0
                         5129.09          322.68
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,41095   ,431,431,431
BEGIN DESCRIPTION:
PIN OAK CREEK 58.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607549.64      10657460.2      3608749.61     10657760.19
      3609199.64     10657810.19
#Sta/Elev= 30
  3774.3  348.62  3790.6  347.27  3871.7   342.7  3928.9  341.15  3998.5  333.49
  4021.7  333.68  4155.7  322.32  4209.8   321.6    4269  315.42  4342.7  313.28
  4704.5  314.46  4732.9   312.4  4874.5  312.97  4980.3  314.17  4993.2  302.12
    4997  301.58  4999.8  301.08    5003  301.58  5008.6  307.76  5013.7  307.76
  5021.3  313.82  5082.3  313.64  5152.1  316.92  5182.3  323.78  5212.4  319.79
  5292.9  335.58  5323.1  338.49  5373.4  347.11  5403.6  349.46    5464   359.2
#Mann= 8 ,-1 , 0
  3774.3     .05       0  3790.6      .1       0  3871.7     .05       0
  4342.7     .12       0  4874.5     .16       0    4997     .07       0
    5003     .16       0  5082.3     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,40664   ,421,421,421
BEGIN DESCRIPTION:
PIN OAK CREEK 57.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607399.59     10657960.19      3608599.61     10658160.19
      3609149.57     10658110.19
#Sta/Elev= 30
  3796.7  356.83  3867.7  353.38  3958.9  341.83  4060.3  333.03  4090.7   328.5
  4121.1  329.71  4171.8  323.48  4344.2  313.39  4433.6  311.94  4536.8  313.33
  4597.6  311.37  4888.5  312.45  4952.4   311.5  4972.7  313.21    4993   301.2
    4997  301.03  4999.8  300.53    5003  301.03  5010.7  311.93  5023.3  313.41
  5111.1  312.04  5163.9  314.85  5204.1  321.19  5214.1  320.81  5224.1  315.45
  5254.3  315.45  5264.3  319.57  5314.5  325.13  5414.9  342.28  5565.5  360.99
#Mann= 6 ,-1 , 0
  3796.7     .05       0  4433.6     .12       0  4888.5     .16       0
    4997     .07       0    5003     .16       0  5111.1     .05       0
#XS Ineff= 2 , 0
                         5215.91          319.89
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,40243   ,418,418,418
BEGIN DESCRIPTION:
PIN OAK CREEK 56.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607849.57     10658360.18      3608449.61     10658560.19
      3609049.64     10658460.18
#Sta/Elev= 30
  4348.1  324.59  4485.2  312.84  4495.7  310.78  4510.4  311.57  4623.2  311.91
  4690.8  312.02  4716.3  312.02  4896.3     312  4917.3  310.76  4983.1  312.84
  4990.7  301.66    4997  301.57  4999.8  301.07    5003  301.57  5008.5  306.74
  5013.5   303.1  5021.1  312.28  5031.3  313.05  5149.5  312.59  5173.2  314.95
  5183.4  318.83  5203.6  319.74  5213.8  315.45  5386.1  315.45  5396.2  320.46
  5426.7  324.53  5467.2  333.52  5517.9  338.25  5555.9  344.21  5588.9  346.79
#Mann= 8 ,-1 , 0
  4348.1     .05       0  4510.4     .16       0  4623.2     .12       0
  4690.8     .05       0  4716.3     .16       0    4997     .07       0
    5003     .16       0  5149.5     .05       0
#XS Ineff= 2 , 0
                         5205.45          318.52
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,39825   ,738,738,738
BEGIN DESCRIPTION:
PIN OAK CREEK 55.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607749.59     10658360.17      3608349.61     10658960.19
      3608949.58     10659010.19
#Sta/Elev= 30
  4170.8   336.9  4255.7  328.14  4298.1  325.53    4383  317.95    4482  312.11
  4637.5  311.45  4679.9  309.94  4722.4  311.52  4788.5  310.56  4923.1  311.47
  4976.9  311.36  4991.1  297.96    4997  297.96  4999.8  297.46    5003  297.96
  5015.8  312.06  5129.7  310.98  5230.1  311.96  5245.5  312.93  5260.2  315.89
  5270.2  316.69  5280.3  316.69  5300.3  313.55  5322.9  312.95  5430.8   315.7
    5491  320.72  5521.1   319.8  5563.7  325.15  5591.3  332.93  5621.4   336.7
#Mann= 6 ,-1 , 0
  4170.8     .05       0  4788.5      .1       0  4923.1     .12       0
    4997     .07       0    5003     .12       0  5245.5     .05       0
#XS Ineff= 2 , 0
                         5283.52          316.35
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,39087   ,923,923,923
BEGIN DESCRIPTION:
PIN OAK CREEK 53.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607380.47     10659312.12      3607784.11     10659627.22
      3609109.59     10659668.88
#Sta/Elev= 30
  4140.2  331.61    4224  326.87  4358.8  314.42  4443.8   308.8  4586.7  307.87
  4967.9  310.04  4977.9   301.7  4987.9  297.54    4997  297.54  4999.8  297.04
    5003  297.54  5007.9  304.47  5017.9   309.9    5158  309.08  5215.9  310.72
  5223.6  314.63  5238.1  315.48  5258.1  312.58  5358.1  312.59  5398.1  321.48
  5412.9  320.81  5438.2  317.61  5508.2  317.54  5638.3  322.48  5709.3   329.4
  5735.9  332.08  5808.3   337.4  5898.4   346.9  5928.4  347.75  5978.4  346.19
#Mann= 7 ,-1 , 0
  4140.2     .05       0    4997     .03       0    5003     .05       0
  5215.9     .16       0  5412.9     .12       0  5709.3     .16       0
  5735.9     .05       0
#XS Ineff= 2 , 0
                         5253.41          313.65
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,38164   ,769,769,769
BEGIN DESCRIPTION:
PIN OAK CREEK 52.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3606074.62      10660158.9      3607093.06     10659990.72
      3608326.46     10660649.46      3608859.11     10660661.14
#Sta/Elev= 30
  2781.4  348.29  2818.9  346.84  3120.9  334.69  3437.2  318.29  3663.3  311.55
  3729.5  314.89  3785.5  310.59  4025.1  306.48    4732  306.64  4970.6   308.1
  4977.4  307.54  4986.8  302.98  4992.5  296.59    4997  294.93  4999.8  294.43
    5003  294.93  5014.5  298.15  5022.8  308.22  5104.2  307.92  5162.4  308.21
  5184.4  310.66  5192.8  314.95  5200.7  315.79    5216  315.36  5235.1  310.55
  5285.1  311.22  5575.2  329.86  5625.2  326.53  5685.2  332.24  5744.7  341.25
#Mann= 7 ,-1 , 0
  2781.4     .05       0  2818.9     .16       0  3437.2     .05       0
    4732     .12       0    4997     .07       0    5003     .12       0
  5104.2     .05       0
#XS Ineff= 2 , 0
         3703.12  312.53 5226.42          312.38
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,37395   ,544,544,544
BEGIN DESCRIPTION:
PIN OAK CREEK 51.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606499.57     10660410.17      3607699.61     10660910.19
      3608899.57     10661410.17
#Sta/Elev= 30
  3717.3  328.31  4031.5  308.43  4151.2   305.4  4789.8  304.65  4931.2  306.06
    4955  308.81  4978.9  306.48  4984.8   297.2    4997  295.21  4999.8  294.71
    5003  295.21  5026.5  306.79  5043.5  306.18    5132  306.35  5191.2  306.44
  5233.5  301.66  5238.9  303.83  5279.1  297.27  5297.8   295.7  5331.5  296.76
  5374.8  311.31  5392.7  312.66    5422  307.68  5894.8  307.68  5927.3  314.67
  6024.8   323.7  6066.5  320.26  6154.8   320.6  6219.8  324.91  6317.3  337.81
#Mann= 7 ,-1 , 0
  3717.3     .05       0    4997     .03       0    5003     .05       0
  5043.5     .12       0    5132     .05       0  5279.1     .08       0
  5297.8     .05       0
#XS Ineff= 2 , 0
                         5390.34          312.65
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,36851   ,510,510,510
BEGIN DESCRIPTION:
PIN OAK CREEK 50.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606039.78     10660529.52      3607489.46     10661328.15
      3608348.64     10662265.43
#Sta/Elev= 30
  3521.6  342.68  4089.7  314.98  4567.8  304.12  4752.4  302.67  4758.1  304.75
  4765.9  297.15  4788.7  304.06  4926.6  299.61  4958.8  303.78  4964.5  300.05
  4980.6  302.02    4997  291.85  4999.8  291.35    5003  291.85  5008.1   293.5
    5017  303.67  5024.1  305.99  5154.8  303.96  5668.3  306.34  5744.3  308.21
  5806.3  309.63  5884.7  311.49  6082.2  321.49  6165.6  324.11  6220.2   326.6
    6306  330.81  6332.2  330.02    6339  327.14  6358.1   331.2  6448.2  335.43
#Mann= 12 ,-1 , 0
  3521.6     .05       0    4997    .035       0    5003     .05       0
  5668.3     .16       0  5744.3     .12       0  5806.3     .16       0
  5884.7     .12       0  6082.2     .16       0  6165.6     .12       0
  6220.2     .16       0    6306     .12       0  6358.1     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,36341   ,705,705,705
BEGIN DESCRIPTION:
PIN OAK CREEK 49.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606126.66     10661371.56      3607376.62     10661597.25
      3607819.32     10662092.04
#Sta/Elev= 30
  4021.5  343.29  4101.1  342.63  4217.6  331.15  4300.8  326.55  4500.5  312.32
  4600.3  305.53  4700.2  303.63    4746  302.53  4806.9  303.16  4817.1  296.02
    4826  294.84  4831.1  296.57  4837.4  303.24  4979.7  304.87  4989.9  293.38
    4997  290.48  4999.8  289.98    5003  290.48  5010.2  292.46  5030.5  304.55
  5052.4  303.94  5172.8  303.29  5254.1  304.83  5309.7  303.59  5451.8  304.76
  5472.7   303.9  5669.8  307.82  5728.9  310.73  5942.5   323.5  5955.6  324.34
#Mann= 12 ,-1 , 0
  4021.5      .1       0  4101.1     .15       0  4300.8     .05       0
  4500.5      .1       0  4600.3     .16       0  4700.2     .12       0
    4997     .07       0    5003     .12       0  5052.4     .05       0
  5669.8     .16       0  5728.9     .12       0  5942.5     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,35636   ,577,577,577
BEGIN DESCRIPTION:
PIN OAK CREEK 48.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606499.56      10662060.2      3606899.61     10661960.19
      3607699.63     10662160.19
#Sta/Elev= 30
  4572.8  327.96  4714.6  314.67  4719.7  315.04  4755.8  310.73  4838.3  305.04
  4925.9  300.77  4954.2  303.41    4962  301.61  4967.1  302.91  4974.8  300.14
  4982.6  294.14  4987.7  294.14    4997  289.95  4999.8  289.45    5003  289.95
  5008.4  291.99  5016.1  299.02  5026.4  303.53  5067.6  303.14  5090.8  300.36
  5108.8  302.09  5126.9  300.36    5132  303.36  5162.2  302.57  5263.2  302.56
  5364.2   303.4  5428.4  303.02  5479.9  304.56  5613.9  310.06  5809.8  321.17
#Mann= 6 ,-1 , 0
  4572.8     .12       0    4997     .07       0    5003     .12       0
  5162.2     .07       0  5263.2     .05       0  5364.2     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,35059   ,582,582,582
BEGIN DESCRIPTION:
PIN OAK CREEK 47.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3606449.12     10662178.71      3607652.23     10663003.35
#Sta/Elev= 30
  4498.7  328.23  4543.6  325.66  4585.6   320.8  4641.1  316.48  4681.1  312.23
  4838.8  301.41  4896.3  299.68    4960  302.05    4983  296.71    4997  288.18
  4999.8  287.68    5003  288.18  5003.9  290.17    5010  294.55  5018.8  299.03
  5032.7  298.69  5054.7  301.94  5081.7  302.63  5204.3  300.87  5284.8   302.3
  5356.6  301.69  5377.6  303.26  5400.4  302.11  5420.7   303.2  5443.2  302.08
  5457.1  303.44  5464.2  301.99  5470.3  303.86  5756.2  310.22  5957.3  312.19
#Mann= 6 ,-1 , 0
  4498.7     .16       0  4641.1     .12       0    4997     .07       0
    5003     .12       0  5400.4     .05       0  5756.2     .12       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,34477   ,717,717,717
BEGIN DESCRIPTION:
PIN OAK CREEK 46.0
END DESCRIPTION:
XS GIS Cut Line= 3
       3606199.6     10662460.18      3606549.61     10662760.19
      3607349.63      10663510.2
#Sta/Elev= 30
    4532  333.48  4535.3  333.48  4539.1  331.76    4560  330.21  4659.9  317.52
  4680.7  316.64    4695  314.46  4737.5  310.95  4769.3  308.31    4830  303.73
  4863.5  302.85  4907.9  300.51  4971.6  301.01  4989.7  292.51  4996.4  292.51
    4997   288.1  4999.8   287.6    5003   288.1  5006.9   288.1  5014.2  291.32
  5028.4  301.91  5108.2  300.88  5141.7  299.74  5261.9  300.73  5282.9  299.56
  5297.1   300.4  5339.6  299.77  5757.2  304.83  5912.5  309.88  6089.6  320.42
#Mann= 7 ,-1 , 0
    4532     .16       0  4737.5     .05       0  4769.3     .16       0
  4863.5     .12       0    4997     .07       0    5003     .12       0
  5108.2     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,33760   ,575,575,575
BEGIN DESCRIPTION:
PIN OAK CREEK 45.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606199.59     10662910.16      3606499.61     10663210.19
      3607199.64     10663660.21
#Sta/Elev= 30
    4577  320.37  4626.2  317.97  4803.3  301.73  4845.7  299.97  4908.8  300.25
  4965.7  300.06    4973  299.64  4987.2  288.67    4997  286.67  4999.8  286.17
    5003  286.67  5004.3  286.67  5008.9   294.3  5014.8  297.72  5024.1  299.82
  5035.8  299.17  5045.2  297.25  5051.2   297.9  5060.4  291.99  5066.4  290.73
  5081.5  297.79  5087.5  298.43  5150.5  299.57    5284  300.24  5513.4  303.16
  5804.7  315.76  5819.9  318.47  5825.9  320.57  5830.5  324.94  5833.5  324.94
#Mann= 10 ,-1 , 0
    4577     .16       0  4626.2     .12       0  4908.8     .16       0
  4965.7     .12       0    4997     .07       0    5003     .12       0
  5035.8     .16       0  5150.5     .05       0    5284     .16       0
  5513.4     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,33185   ,562,562,562
BEGIN DESCRIPTION:
PIN OAK CREEK 44.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605899.63     10662960.22      3606499.61     10663760.19
      3607049.64     10664060.21
#Sta/Elev= 30
    4015  321.56  4122.3  314.64    4215  311.37  4236.8  309.55  4244.3  310.53
  4257.7  311.67  4286.3  310.04  4336.8  307.49  4357.7   304.4  4401.4   301.5
  4507.7  298.46  4636.8  298.43  4651.4  298.74  4657.7  300.27    4665  298.59
  4693.1  298.29    4965  299.18  4972.3  298.59  4978.5   293.6  4986.8  296.63
  4993.1  286.09    4997  285.76  4999.8  285.26    5003  285.76  5017.8  287.13
    5023  290.53  5050.6  297.69  5088.5  298.06  5279.3  311.08  5641.5  340.83
#Mann= 5 ,-1 , 0
    4015     .05       0  4244.3     .16       0  4286.3     .12       0
    4997     .07       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,32623   ,492,492,492
BEGIN DESCRIPTION:
PIN OAK CREEK 43.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605349.62      10663610.2      3606149.61     10664110.19
      3606949.58     10664360.18
#Sta/Elev= 30
  4085.5  323.73  4193.4  318.56  4349.5  306.56  4412.7  301.18  4534.2  297.01
  4564.8  297.39  4570.7  298.85  4592.6  297.07  4738.2  297.47  4768.9  294.42
    4796  296.75  4942.2  296.76  4969.9  298.04  4978.8     297  4984.7  294.55
  4993.5  286.82    4997  285.24  4999.8  284.74    5003  285.24  5015.3  286.08
  5021.2     293  5025.9  295.59  5039.4  297.47  5133.7  296.32  5322.2  299.96
  5468.9  305.53  5636.5  318.01  5688.9   323.7  5818.3  333.61    5867  339.31
#Mann= 4 ,-1 , 0
  4085.5     .12       0  4349.5     .05       0    4997     .03       0
    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,32131   ,564,564,564
BEGIN DESCRIPTION:
PIN OAK CREEK 42.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605049.64     10663610.22      3605749.61     10664360.19
      3606549.58     10665160.16
#Sta/Elev= 30
  3966.8  337.52    4158  325.15    4391  312.74  4519.4  308.73  4532.7  309.15
    4561  307.45  4667.1  298.36  4745.2   295.5  4773.5   296.3  4865.4   296.7
  4886.4  295.61  4893.7   293.9  4900.6  294.77  4914.3  293.47  4964.6  297.07
  4978.7  296.59  4985.6  287.58  4989.2  284.35    4997  284.35  4999.8  283.85
    5003  284.35  5016.7  293.65  5020.9  296.74  5035.1  297.04  5233.1  295.35
  5431.1  299.86  5614.9     311  5784.6  324.64  5954.3   340.5    6124  354.57
#Mann= 7 ,-1 , 0
  3966.8     .12       0  4519.4     .05       0  4773.5     .16       0
  4914.3     .12       0    4997     .07       0    5003     .12       0
  5016.7     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,31567   ,805,805,805
BEGIN DESCRIPTION:
PIN OAK CREEK 41.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604599.63     10664010.21      3605399.61     10664710.19
      3606199.64     10665360.22
#Sta/Elev= 30
  3963.4  336.12  4076.8  321.17    4160  313.34    4233   308.2    4285  306.32
  4622.6  297.47  4679.5  295.31  4749.7  295.28  4930.9  295.28  4976.6  295.59
  4990.8  284.39    4997  284.15  4999.8  283.65    5003  284.15  5012.6  291.12
  5019.3  290.93  5033.6   294.8  5083.1  292.94  5090.8  286.13  5103.9  288.69
    5111  293.62  5126.2  295.92  5140.6  293.84  5147.1  295.79    5297  294.74
  5552.9  300.65  5608.9  303.98  5800.7   321.1    5851  328.84  6057.2  351.69
#Mann= 10 ,-1 , 0
  3963.4     .05       0    4160     .12       0    4233     .05       0
    4285     .12       0  4622.6     .16       0  4749.7     .05       0
  4930.9     .12       0    4997     .07       0    5003     .12       0
    5111     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,30762   ,575,575,575
BEGIN DESCRIPTION:
PIN OAK CREEK 40.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604499.58     10664160.15      3605049.61     10664960.19
      3605849.57     10665410.17
#Sta/Elev= 30
  3998.1  335.93  3998.6  335.93  4119.5  320.31  4283.9  304.76  4343.2  300.49
  4450.7  299.81  4588.1  294.78  4803.2  293.44  4913.6   294.2  4971.8  295.34
  4976.9  292.04  4982.7  285.15    4997   282.9  4999.8   282.4    5003   282.9
  5014.5  282.98  5020.3  286.47  5026.3  294.27  5036.2  295.31  5086.7  294.37
  5109.1  294.05  5365.8   294.2  5680.3  300.88  5754.6  304.09  5770.5  306.51
  5829.5  310.79  5857.2  314.63  5863.9  319.56  5878.9  320.51  5886.8  318.45
#Mann= 8 ,-1 , 0
  3998.1     .05       0  3998.6     .12       0  4283.9     .05       0
  4913.6     .07       0    4997     .07       0    5003     .07       0
  5086.7     .07       0  5109.1     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,30187   ,1395,1395,1395
BEGIN DESCRIPTION:
Mapping XS a2f12263
END DESCRIPTION:
XS GIS Cut Line= 3
      3604113.51     10664329.01      3604863.52     10665276.94
      3605952.08     10665610.27
#Sta/Elev= 30
  3875.8  327.44  3888.7  325.76  3895.1  326.49  3909.5   323.1  3930.3  322.57
  3938.4  320.44  4023.3  314.59  4037.7  312.08  4176.8  302.31    4323  294.42
  4685.2  292.78  4935.8  293.75  4970.5  294.45  4991.3  292.45    4997  281.18
  4999.8  280.68    5003  281.18  5012.2  281.78  5020.2  290.47  5026.6  294.16
  5034.6  295.03  5135.8  292.97  5185.7  292.88    5206  288.62  5213.2  292.87
  5237.3  293.49  5594.5  295.66  5796.3  300.05    5959  307.26    6223  327.55
#Mann= 6 ,-1 , 0
  3875.8     .12       0  4176.8     .05       0  4935.8     .12       0
    4997     .07       0    5003     .12       0  5135.8     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,28792   ,459,459,459
BEGIN DESCRIPTION:
PIN OAK CREEK 39.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3603899.98     10664349.84      3604426.02     10665724.85
      3604717.69     10665802.98      3605976.35     10665698.96
#Sta/Elev= 30
  3396.9  322.71  3441.7  321.09  3507.6  313.75    3590   305.6  3637.3  302.89
  3715.4  297.97  3770.2  296.76  4893.5  291.06  4948.1  293.16  4955.6  293.15
  4976.3  283.74  4983.9  278.21  4989.1  279.32    4997   278.1  4999.8   277.6
    5003   278.1  5007.4   283.6  5017.7  291.14    5024   292.6  5029.1   291.3
  5069.5  290.35  5090.2  293.11    5151  294.35  5213.1  292.91  5393.7  296.61
  5574.3  296.82  5865.3  301.29  6246.6  318.65  6360.2  325.79    6434  332.72
#Mann= 7 ,-1 , 0
  3396.9     .16       0  3507.6     .12       0  3637.3     .05       0
  4948.1     .12       0    4997     .07       0    5003     .12       0
    5151     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,28333   ,152,152,152
BEGIN DESCRIPTION:
PIN OAK CREEK 38.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3603416.22     10665856.83      3604258.23     10666060.82
      3604570.73     10666039.12      3606024.66     10665830.79
#Sta/Elev= 30
    3980  324.84  4065.8   325.3    4608   293.9    4714     291  4904.3   291.8
    4968  291.43  4978.1  288.65  4988.1  277.58    4997   277.2  4999.8   276.7
    5003   277.2  5008.1  281.56  5018.2  284.41  5058.3  287.43  5067.6  287.69
  5072.6  282.96  5159.6  284.57  5185.5  286.88  5190.6  289.43    5212  286.77
  5229.2  286.36  5249.4   297.7  5269.6  300.77    5310  294.82  5421.1   294.8
    5906  302.24  6209.1  315.03  6315.3  322.29    6401   322.5  6628.4  339.75
#Mann= 5 ,-1 , 0
    3980     .05       0  4904.3     .12       0    4997     .07       0
    5003     .12       0    5212     .05       0
#XS Ineff= 2 , 0
                         5279.83          299.17
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,28181   ,604,604,604
BEGIN DESCRIPTION:
PIN OAK CREEK 37.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603599.63     10666210.19      3604399.61     10666160.19
       3605799.6     10666060.19
#Sta/Elev= 30
  4128.9  322.34  4329.3  306.46  4449.7  298.98  4527.2   293.6  4639.9  290.54
  4830.2  290.62  4840.3  290.77  4847.8  293.28  4870.3  291.42  4932.9  291.72
  4940.5  290.77  4950.5  285.95  4960.5  283.65  4980.6   281.1    4997  277.14
  4999.8  276.64    5003  277.14  5030.7  289.25  5040.7  288.25  5050.7  290.63
  5060.8  296.44  5116.6  296.07  5278.8  294.93  5441.7  296.16  5704.9   300.9
    5933  312.73  6073.3  321.69    6126  323.16  6261.3  335.63    6334  338.33
#Mann= 5 ,-1 , 0
  4128.9     .16       0  4449.7     .05       0    4997     .03       0
    5003     .05       0  5116.6     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,27577   ,541,541,541
BEGIN DESCRIPTION:
PIN OAK CREEK 36.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603699.65     10666810.17      3604349.61     10666560.19
      3605599.59     10666160.19
#Sta/Elev= 30
  4325.8  331.66  4347.2  328.06    4510  311.86  4594.7  301.22  4619.3  300.39
  4657.9  296.24  4783.3  290.44  4957.9  290.69  4977.2  282.88  4982.5  283.44
    4990  276.25    4997     276  4999.8   275.5    5003     276  5010.9  282.38
  5019.5  288.46  5043.5  291.29  5204.4  291.23  5326.7  291.46  5498.9  296.03
  5589.2   294.1  5851.6   300.7  6135.1  317.93  6152.5  320.08  6157.8  319.33
  6184.7  322.55  6222.1  323.63  6281.1  329.59  6286.4  328.22  6334.6  331.94
#Mann= 5 ,-1 , 0
  4325.8     .05       0    4997     .03       0    5003     .05       0
  5010.9     .12       0  5204.4     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,27036   ,569,569,569
BEGIN DESCRIPTION:
PIN OAK CREEK 35.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603899.65     10667010.18      3604699.61     10666860.19
      3605499.61     10666260.19
#Sta/Elev= 30
  4194.7  315.24    4215  312.95  4220.9  311.22  4255.7  307.66  4273.5  304.19
  4278.6  304.89  4296.4  302.47  4377.8  296.79  4479.5  291.51  4651.6  288.82
  4967.9  290.26  4982.3  285.64  4988.2  277.25    4997  275.79  4999.8  275.29
    5003  275.79  5006.1   277.9  5011.7   277.9  5015.9  286.31  5022.1  285.38
  5030.5  289.91  5036.7  289.98  5045.1  292.01  5230.5  293.53  5615.9  299.33
  5745.1  306.17  5836.7  313.62  5865.9  314.76  5908.6  319.25  6008.6  327.02
#Mann= 3 ,-1 , 0
  4194.7     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,26467   ,415,415,415
BEGIN DESCRIPTION:
PIN OAK CREEK 34.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603949.61     10667210.19      3604749.61     10667310.19
       3605499.6     10666510.19
#Sta/Elev= 30
  4188.6  310.97  4259.1  303.95  4329.7  298.86  4468.3   294.2  4490.9  291.57
  4511.1  293.24  4611.9  292.54  4710.1     290  4924.3  287.92  4934.4  287.66
  4944.4  284.05    4952  285.62    4957  283.78  4964.6  287.96  4984.7  275.73
    4997  275.22  4999.8  274.72    5003  275.22  5008.8  278.11  5022.9  288.15
  5030.2  288.93  5065.4  290.23  5186.7  289.62  5306.2  289.83  5426.4  296.51
  5546.5  299.48  5751.7  296.43  5900.2  298.13  6027.7  302.62  6091.4  307.45
#Mann= 5 ,-1 , 0
  4188.6     .05       0    4952     .12       0    4997     .07       0
    5003     .12       0  5186.7     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,26052   ,792,792,792
BEGIN DESCRIPTION:
PIN OAK CREEK 33.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603963.05     10668230.69      3604893.65       10667689.
      3605921.44     10666501.48
#Sta/Elev= 30
  3804.9  318.39  3854.3  319.85  3928.2  315.14  4036.3  305.46  4182.8  299.21
  4286.9   298.3  4410.3  294.74  4657.2  290.56  4902.5  288.24  4970.4  288.39
  4984.7  278.15  4991.3  276.89    4997  274.45  4999.8  273.95    5003  274.45
  5012.4  278.09  5019.8  288.01  5094.6     288  5353.2  288.12  5459.6  291.61
  5551.7  292.78  5650.5  291.36  5707.5  292.55  5792.6  291.75  6061.8  296.12
  6111.1  296.99  6317.3  305.89  6380.9  306.47  6409.4  309.45  6452.2  311.77
#Mann= 5 ,-1 , 0
  3804.9     .05       0  4902.5     .12       0    4997     .07       0
    5003     .12       0  5094.6     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,25260   ,565,565,565
BEGIN DESCRIPTION:
PIN OAK CREEK 32.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604582.66     10668578.18      3605329.19     10668005.26
      3606448.97     10666191.05
#Sta/Elev= 30
    3969  320.47    3979  319.76  3987.2  316.91  4015.6  314.86  4179.4  305.95
  4236.4  299.81    4386  291.88  4734.9  285.93  4963.7  288.17    4979   285.4
  4986.5  279.57    4997  274.52  4999.8  274.02    5003  274.52  5006.9  276.02
  5019.5  280.67    5037  287.95  5284.1  286.17  5421.3  290.26  5809.1   291.5
  6091.1  295.74  6396.7  306.32  6419.4  304.49  6440.6  308.75  6467.8  309.34
  6490.7   306.3  6498.6  309.02  6824.9  324.48  6956.2  334.81    7042  339.09
#Mann= 5 ,-1 , 0
    3969     .05       0    4997     .03       0    5003     .05       0
  5006.9     .16       0  5019.5     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,24695   ,739,739,739
BEGIN DESCRIPTION:
PIN OAK CREEK 31.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605049.62     10668910.18      3605849.61     10668110.19
      3606649.59     10667310.21
#Sta/Elev= 30
  3862.5  309.48  3876.6  308.85  3919.1  303.12    4018  294.83  4131.2  287.53
  4187.8   285.6  4272.6  284.92  4343.3  285.99    4414  284.88  4781.7  286.27
    4810  284.88  4852.4  286.97  4875.6  286.41  4881.9   286.4  4951.4  286.72
  4965.6  278.82  4979.7  273.87    4997  272.41  4999.8  271.91    5003  272.41
    5008  278.07  5022.1  282.83  5050.4  287.22  5064.6   287.5  5078.7  286.29
    5206  288.09  5389.8   288.1  5743.4  293.37  5927.2  300.97  6125.2  313.49
#Mann= 5 ,-1 , 0
  3862.5     .05       0  4875.6     .16       0  4881.9     .05       0
    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,23956   ,141,141,141
BEGIN DESCRIPTION:
PIN OAK CREEK 30.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3605554.88     10669472.28      3605737.18     10669324.71
      3606422.94     10668230.96      3607194.17     10666974.46
#Sta/Elev= 30
  3652.5  311.97  3832.6  298.85    3965  292.79  3985.5  291.68  4189.5  283.38
  4416.9  282.81  4529.8  282.18  4669.2  284.56  4675.1   280.1  4690.4  284.05
  4718.6  280.04  4732.8  285.86  4755.7  285.16  4798.2  284.95  4957.9  284.68
    4997  272.04  4999.8  271.54    5003  272.04  5015.6  283.89  5037.3  286.05
  5599.9  291.06  5656.8  293.01    5802  301.87  5881.5   307.2  5946.2  312.28
  6093.6  322.29  6158.9   326.6    6457  345.82  6530.9  350.27  6652.3  359.35
#Mann= 20 ,-1 , 0
  3652.5     .05       0  3832.6     .08       0    3965     .05       0
  3985.5     .08       0  4189.5     .05       0  4416.9     .08       0
  4529.8     .05       0  4755.7     .16       0  4798.2     .05       0
    4997     .04       0    5003     .05       0  5599.9     .08       0
  5656.8     .05       0    5802     .08       0  5881.5     .05       0
  5946.2     .08       0  6093.6     .05       0  6158.9     .08       0
    6457     .05       0  6530.9     .08       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,23815   ,1093,1093,1093
BEGIN DESCRIPTION:
PIN OAK CREEK 29.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605698.98     10669736.18      3606511.48     10668333.39
      3607323.93     10667125.14
#Sta/Elev= 30
  3502.1  324.33  3602.1  315.67  3823.7  300.15  3885.2  296.94  3947.3  292.47
  4124.8   288.8  4171.2  288.29  4231.4  285.09    4238  286.71  4268.7  284.02
  4943.9  285.44  4970.4  282.44  4986.1  271.84    4997  271.84  4999.8  271.34
    5003  271.84  5007.6  283.28  5042.4  284.99    5152  285.32  5269.5  286.55
  5375.2  287.98  5607.9  295.44  5845.2  310.16  5905.2  314.78  6075.4     327
  6093.5  328.29  6315.8  346.39  6384.8  351.92  6559.5  357.54  6579.2  358.28
#Mann= 20 ,-1 , 0
  3502.1     .12       0  3602.1     .05       0  3823.7     .08       0
  3885.2     .05       0  4124.8     .12       0  4171.2     .08       0
    4238     .12       0  4943.9     .12       0    4997     .07       0
    5003     .12       0  5042.4     .05       0    5152     .12       0
  5269.5     .05       0  5375.2     .16       0  5845.2     .05       0
  5905.2     .16       0  6075.4     .05       0  6093.5     .16       0
  6315.8     .08       0  6559.5     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,22722   ,1225,1225,1225
BEGIN DESCRIPTION:
PIN OAK CREEK 28.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606299.62     10669560.18      3606999.61     10669010.19
      3607799.64     10668760.18
#Sta/Elev= 30
  4122.7  309.49  4357.5  290.81  4487.4  284.13  4506.8  283.32  4514.9  279.27
  4521.3   283.2  4535.7  277.25  4542.4  282.71  4556.2  281.67  4707.4  282.68
  4742.7  278.73  4757.1  282.69  4792.4  279.89  4827.6  283.08    4956  283.44
  4970.4  275.29  4991.2  274.82    4997  271.84  4999.8  271.34    5003  271.84
  5015.5  272.03  5044.3  284.04  5091.2  283.31  5322.8  287.21  5379.6  288.84
  5396.9  285.65  5427.7  288.64  5670.6  300.33  5713.3  304.37  5851.1  317.94
#Mann= 11 ,-1 , 0
  4122.7     .16       0  4357.5     .12       0  4487.4     .16       0
  4556.2     .12       0    4997     .07       0    5003     .12       0
  5091.2     .16       0  5322.8     .12       0  5427.7     .16       0
  5670.6     .05       0  5713.3     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,21497   ,629,629,629
BEGIN DESCRIPTION:
PIN OAK CREEK 26.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606855.99     10670111.62      3607571.84     10669545.08
      3608145.64     10668493.45
#Sta/Elev= 30
  4230.6  302.21  4255.7  300.61  4270.1  295.85  4311.8  293.38  4326.2  289.94
  4421.8  285.12  4620.1  283.97  4725.3  281.15  4760.5  282.23  4789.4  280.12
  4847.1  282.11  4967.3  280.41  4981.7  273.25  4988.1  272.61    4997  268.72
  4999.8  268.22    5003  268.72    5017  271.52    5025  282.25  5081.1  281.03
  5183.3  282.77  5271.6   287.9  5315.8  293.36  5527.9  306.57  5647.5  310.37
  5898.1  325.83  6088.9  322.29  6126.8  323.92  6257.8  322.53  6341.5  325.61
#Mann= 6 ,-1 , 0
  4230.6     .12       0  4421.8     .05       0  4620.1     .12       0
    4997     .07       0    5003     .12       0  5315.8     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,20868   ,490,490,490
BEGIN DESCRIPTION:
PIN OAK CREEK 25.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607249.61     10670660.19      3607849.61     10670010.19
      3608349.61     10669510.18
#Sta/Elev= 30
  4109.7  325.54  4145.1  320.54  4166.1  319.23  4258.5  308.25  4328.9  297.46
  4378.8  291.31  4480.3  283.21    4639  279.42  4668.5  279.31  4690.1   280.8
  4707.7  280.09  4845.4  279.57    4973   280.8  4980.4  274.19  4987.2   272.9
  4990.9  268.89    4997  268.89  4999.8  268.39    5003  268.89  5022.6  272.46
  5050.9  281.17  5093.3  280.47  5107.4   278.3  5121.6  280.06  5203.1  281.76
  5347.8  285.15  5404.4  288.27  5588.3  304.13  5630.7  309.09  5701.4  312.79
#Mann= 7 ,-1 , 0
  4109.7     .16       0  4480.3     .05       0    4639     .16       0
  4707.7     .12       0    4997     .07       0    5003     .12       0
  5203.1     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,20378   ,777,777,777
BEGIN DESCRIPTION:
PIN OAK CREEK 24.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607440.04     10670953.74       3608259.5     10670175.94
      3608662.28     10669460.67
#Sta/Elev= 30
  4218.2  325.51  4298.3  320.37  4305.2  318.52  4326.7  319.17  4361.9  314.17
  4469.8  304.31    4597  292.82    4751  283.21  4892.8  279.73  4977.1  278.32
  4991.3  273.38    4997   267.4  4999.8   266.9    5003   267.4  5026.9  278.28
  5033.8  279.69  5098.3  280.29  5210.5  279.32  5246.1  275.45    5253  275.49
  5260.3  279.63  5267.2  279.77  5288.6  277.79  5630.4  281.19  5733.4   285.1
  5801.6  294.37  5888.3  301.36    5917  300.79  5990.9  304.07  6168.9  315.41
#Mann= 8 ,-1 , 0
  4218.2     .05       0  4469.8     .16       0    4597     .05       0
  4892.8     .16       0    4997     .07       0    5003     .16       0
  5098.3     .12       0  5630.4     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,19601   ,503,503,503
BEGIN DESCRIPTION:
PIN OAK CREEK 23.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607662.28     10670995.39       3608509.5     10670641.22
      3609141.26     10669474.91
#Sta/Elev= 30
  3934.4  310.56  4050.7  302.06  4105.4   295.3    4267  283.01    4581  277.62
  4646.9  279.24  4679.4   277.8  4685.8  275.57  4709.6  278.68  4748.9  278.17
  4853.9  277.68  4970.8  278.19    4979  276.85    4987  273.29  4992.7  267.71
    4997  267.18  4999.8  266.68    5003  267.18  5024.4  279.09  5399.8  282.68
  5631.8  285.97  5707.9  288.65  5789.7  289.26  5820.5  286.97  5865.8  289.55
  5893.3  288.51  5909.5  292.86  5915.2  288.94  5945.6  295.72  6179.1  308.42
#Mann= 9 ,-1 , 0
  3934.4     .16       0  4105.4     .05       0    4581     .16       0
  4748.9     .07       0  4853.9     .12       0    4997     .07       0
    5003     .12       0  5399.8     .16       0  5631.8     .12       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,19098   ,636,636,636
BEGIN DESCRIPTION:
PIN OAK CREEK 22.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3607401.91     10671162.48      3609516.18     10670717.94
#Sta/Elev= 30
  3759.2  326.11  3797.5  325.43  3899.9  316.42  3938.1  310.38  3943.2  312.55
    3951  311.98  4012.3  305.39  4037.8  304.43  4082.5   298.2  4126.9  295.37
  4339.3  282.69  4476.5  279.19  4884.3  276.79  4972.9  278.48  4983.1  275.04
  4993.3  267.97    4997  267.25  4999.8  266.75    5003  267.25  5009.1  272.64
    5024  277.75  5238.6  277.27  5279.4  281.82  5293.1  280.07  5371.4  283.68
  5505.9  295.17  5508.1  295.44  5708.6  313.98  5791.4  319.46  5919.7  332.64
#Mann= 10 ,-1 , 0
  3759.2     .05       0  3797.5     .16       0  4126.9     .05       0
  4476.5     .16       0  4884.3     .12       0    4997     .07       0
    5003     .12       0  5293.1     .16       0  5505.9     .12       0
  5508.1     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,18462   ,374,374,374
BEGIN DESCRIPTION:
PIN OAK CREEK 21.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607849.61     10671710.19      3608649.61     10671310.19
      3609449.59      10670810.2
#Sta/Elev= 30
    4103  305.43  4200.8  298.37  4312.6  285.23  4361.8  281.87  4446.8   277.3
  4545.5  276.37  4700.4  276.18  4748.9  276.27    4908  276.63  4938.7  274.99
  4944.3  276.48  4961.1  274.43  4966.7  277.04  4975.1  277.58  4983.4   277.2
    4989  274.71  4994.6  265.93    4997  265.86  4999.8  265.36    5003  265.86
    5011  265.86  5026.3  275.03  5032.8  276.99    5161  276.71    5294   278.5
  5440.2  288.68  5555.8  294.08  5723.2  308.19  5838.8  315.52  5940.8  326.18
#Mann= 8 ,-1 , 0
    4103     .16       0  4361.8     .05       0  4545.5     .16       0
  4700.4     .05       0  4748.9     .12       0    4997     .07       0
    5003     .12       0    5161     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
