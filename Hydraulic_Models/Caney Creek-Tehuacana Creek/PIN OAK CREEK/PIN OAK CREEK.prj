HEC-RAS study PIN OAK CREEK.prj: PIN OAK CREEK Base Level Engineering

--- PIN OAK CREEK.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,30187   ,1395,1395,1395
BEGIN DESCRIPTION:
Mapping XS a2f12263
END DESCRIPTION:
XS GIS Cut Line= 3
      3604113.51     10664329.01      3604863.52     10665276.94
      3605952.08     10665610.27
#Sta/Elev= 30
  3875.8  327.44  3895.1  326.49  3909.5   323.1  3930.3  322.57  3938.4  320.44
  4023.3  314.59  4037.7  312.08  4176.8  302.31    4323  294.42  4685.2  292.78
  4935.8  293.75  4962.5  294.52  4991.3  292.45  4999.4  282.59  5002.8  281.18
  5005.5  280.68  5008.8  281.18  5012.2  281.78  5020.2  290.47  5026.6  294.16
  5034.6  295.03  5135.8  292.97  5185.7  292.88    5206  288.62  5213.2  292.87
  5237.3  293.49  5594.5  295.66  5796.3  300.05    5959  307.26    6223  327.55
#Mann= 6 ,-1 , 0
  3875.8     .12       0  4176.8     .05       0  4935.8     .12       0
  5002.8     .07       0  5008.8     .12       0  5135.8     .05       0
Bank Sta=4962.5,5034.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,28792   ,459,459,459
BEGIN DESCRIPTION:
PIN OAK CREEK 39.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3603899.98     10664349.84      3604426.02     10665724.85
      3604717.69     10665802.98      3605976.35     10665698.96
#Sta/Elev= 30
  3396.9  322.71  3441.7  321.09  3507.6  313.75    3590   305.6  3637.3  302.89
  3715.4  297.97  3770.2  296.76  4893.5  291.06  4948.1  293.16  4955.6  293.15
  4976.3  283.74  4983.9  278.21  4989.1  279.32    4994   278.1  4996.8   277.6
    5000   278.1  5017.7  291.14    5024   292.6  5029.1   291.3  5038.5  292.39
  5069.5  290.35  5090.2  293.11    5151  294.35  5213.1  292.91  5393.7  296.61
  5574.3  296.82  5865.3  301.29  6246.6  318.65  6360.2  325.79    6434  332.72
#Mann= 7 ,-1 , 0
  3396.9     .16       0  3507.6     .12       0  3637.3     .05       0
  4948.1     .12       0    4994     .07       0    5000     .12       0
    5151     .05       0
Bank Sta=4948.1,5151
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,28333   ,152,152,152
BEGIN DESCRIPTION:
PIN OAK CREEK 38.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3603416.22     10665856.83      3604258.23     10666060.82
      3604570.73     10666039.12      3606024.66     10665830.79
#Sta/Elev= 30
    3980  324.84  4065.8   325.3    4608   293.9    4714     291  4904.3   291.8
  4925.3  292.12    4968  291.43  4978.1  288.65  4988.1  277.58  4995.1   277.2
  4997.9   276.7  5001.1   277.2  5018.2  284.41  5058.3  287.43  5067.6  287.69
  5072.6  282.96  5159.6  284.57  5190.6  289.43    5212  286.77  5229.2  286.36
  5239.3  292.75  5256.1  299.58  5269.6  300.77    5310  294.82  5421.1   294.8
    5906  302.24  6209.1  315.03  6315.3  322.29    6401   322.5  6628.4  339.75
#Mann= 5 ,-1 , 0
    3980     .05       0  4904.3     .12       0  4995.1     .07       0
  5001.1     .12       0    5212     .05       0
#XS Ineff= 2 , 0
                         5279.83          299.17
Permanent Ineff=
       F       F
Bank Sta=4925.3,5239.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,28181   ,604,604,604
BEGIN DESCRIPTION:
PIN OAK CREEK 37.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603599.63     10666210.19      3604399.61     10666160.19
       3605799.6     10666060.19
#Sta/Elev= 30
  4128.9  322.34  4329.3  306.46  4449.7  298.98  4527.2   293.6  4639.9  290.54
  4830.2  290.62  4840.3  290.77  4847.8  293.28  4870.3  291.42  4927.9  291.72
  4940.5  290.77  4950.5  285.95  4980.6   281.1  4995.1  277.14  4997.9  276.64
  5001.1  277.14  5001.6  277.26  5010.6  279.67  5030.7  289.25  5040.7  288.25
  5050.7  290.63  5060.8  296.44  5116.6  296.07  5278.8  294.93  5441.7  296.16
  5704.9   300.9  6073.3  321.69    6126  323.16  6261.3  335.63    6334  338.33
#Mann= 6 ,-1 , 0
  4128.9     .16       0  4449.7     .05       0  4995.1     .03       0
  5001.1     .05       0  5001.6     .12       0  5116.6     .05       0
Bank Sta=4927.9,5060.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,27577   ,541,541,541
BEGIN DESCRIPTION:
PIN OAK CREEK 36.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603699.65     10666810.17      3604349.61     10666560.19
      3605599.59     10666160.19
#Sta/Elev= 30
  4325.8  331.66  4347.2  328.06    4510  311.86  4594.7  301.22  4619.3  300.39
  4657.9  296.24  4783.3  290.44  4957.9  290.69  4977.2  282.88  4982.5  283.44
    4990  276.25  4997.8     276  5000.5   275.5  5003.8     276  5010.9  282.38
  5019.5  288.46  5043.5  291.29  5204.4  291.23  5326.7  291.46  5498.9  296.03
  5589.2   294.1  5851.6   300.7  6135.1  317.93  6152.5  320.08  6157.8  319.33
  6184.7  322.55  6222.1  323.63  6281.1  329.59  6286.4  328.22  6334.6  331.94
#Mann= 5 ,-1 , 0
  4325.8     .05       0  4997.8     .03       0  5003.8     .05       0
  5010.9     .12       0  5204.4     .05       0
Bank Sta=4957.9,5043.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,27036   ,569,569,569
BEGIN DESCRIPTION:
PIN OAK CREEK 35.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603899.65     10667010.18      3604699.61     10666860.19
      3605499.61     10666260.19
#Sta/Elev= 30
  4194.7  315.24    4215  312.95  4220.9  311.22  4255.7  307.66  4273.5  304.19
  4278.6  304.89  4296.4  302.47  4377.8  296.79  4479.5  291.51  4651.6  288.82
  4967.9  290.26  4982.3  285.64  4988.2  277.25  4995.4  275.79  4998.2  275.29
  5001.4  275.79  5006.1   277.9  5011.7   277.9  5015.9  286.31  5022.1  285.38
  5030.5  289.91  5051.3  291.98  5230.5  293.53  5615.9  299.33  5745.1  306.17
  5836.7  313.62  5865.9  314.76  5908.6  319.25  6001.3  325.72  6008.6  327.02
#Mann= 3 ,-1 , 0
  4194.7     .05       0  4995.4     .03       0  5001.4     .05       0
Bank Sta=4967.9,5051.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,26467   ,415,415,415
BEGIN DESCRIPTION:
PIN OAK CREEK 34.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603949.61     10667210.19      3604749.61     10667310.19
       3605499.6     10666510.19
#Sta/Elev= 30
  4188.6  310.97  4329.7  298.86  4468.3   294.2  4490.9  291.57  4511.1  293.24
  4611.9  292.54  4710.1     290  4924.3  287.92  4934.4  287.66  4944.4  284.05
    4952  285.62    4957  283.78  4964.6  287.96  4984.7  275.73  4989.3  275.22
  4992.1  274.72  4995.3  275.22  5001.9  275.27  5008.8  278.11  5022.9  288.15
  5030.2  288.93  5065.4  290.23  5186.7  289.62  5306.2  289.83  5426.4  296.51
  5546.5  299.48  5751.7  296.43  5900.2  298.13  6027.7  302.62  6091.4  307.45
#Mann= 5 ,-1 , 0
  4188.6     .05       0    4952     .12       0  4989.3     .07       0
  4995.3     .12       0  5186.7     .05       0
Bank Sta=4964.6,5030.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,26052   ,792,792,792
BEGIN DESCRIPTION:
PIN OAK CREEK 33.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603963.05     10668230.69      3604893.65       10667689.
      3605921.44     10666501.48
#Sta/Elev= 30
  3804.9  318.39  3854.3  319.85  3928.2  315.14  4036.3  305.46  4182.8  299.21
  4286.9   298.3  4410.3  294.74  4657.2  290.56  4902.5  288.24  4962.8  288.51
  4970.4  288.39  4984.7  278.15    4996  274.45  4998.7  273.95    5002  274.45
  5012.4  278.09  5019.8  288.01  5040.7  288.62  5094.6     288  5353.2  288.12
  5459.6  291.61  5551.7  292.78  5650.5  291.36  5707.5  292.55  5792.6  291.75
  6061.8  296.12  6111.1  296.99  6317.3  305.89  6380.9  306.47  6452.2  311.77
#Mann= 5 ,-1 , 0
  3804.9     .05       0  4902.5     .12       0    4996     .07       0
    5002     .12       0  5094.6     .05       0
Bank Sta=4962.8,5040.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,25260   ,565,565,565
BEGIN DESCRIPTION:
PIN OAK CREEK 32.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604582.66     10668578.18      3605329.19     10668005.26
      3606448.97     10666191.05
#Sta/Elev= 30
    3969  320.47  3987.2  316.91  4015.6  314.86  4179.4  305.95  4236.4  299.81
    4386  291.88  4734.9  285.93  4957.8  288.02    4979   285.4  4986.5  279.57
  4997.3  274.52  5000.1  274.02  5003.3  274.52  5006.9  275.97  5019.5  280.67
    5037  287.95  5284.1  286.17  5421.3  290.26  5691.6  290.47  6091.1  295.74
  6351.9  305.36  6396.7  306.32  6419.4  304.49  6440.6  308.75  6467.8  309.34
  6490.7   306.3  6498.6  309.02  6824.9  324.48  6956.2  334.81    7042  339.09
#Mann= 5 ,-1 , 0
    3969     .05       0  4997.3     .03       0  5003.3     .05       0
  5006.9     .16       0  5019.5     .05       0
Bank Sta=4957.8,5037
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,24695   ,739,739,739
BEGIN DESCRIPTION:
PIN OAK CREEK 31.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605049.62     10668910.18      3605849.61     10668110.19
      3606649.59     10667310.21
#Sta/Elev= 30
  3862.5  309.48  3876.6  308.85  3919.1  303.12    4018  294.83  4131.2  287.53
  4187.8   285.6  4272.6  284.92  4343.3  285.99    4414  284.88  4781.7  286.27
    4810  284.88  4852.4  286.97  4875.6  286.41  4881.9   286.4  4951.4  286.72
  4965.6  278.82  4987.3  272.41  4990.1  271.91  4993.3  272.41  4997.4  272.41
    5008  278.07  5022.1  282.83  5050.4  287.22  5064.6   287.5  5078.7  286.29
    5206  288.09  5389.8   288.1  5743.4  293.37  5927.2  300.97  6125.2  313.49
#Mann= 5 ,-1 , 0
  3862.5     .05       0  4875.6     .16       0  4881.9     .05       0
  4987.3     .03       0  4993.3     .05       0
Bank Sta=4951.4,5064.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,23956   ,141,141,141
BEGIN DESCRIPTION:
PIN OAK CREEK 30.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3605554.88     10669472.28      3605737.18     10669324.71
      3606422.94     10668230.96      3607194.17     10666974.46
#Sta/Elev= 30
  3652.5  311.97  3832.6  298.85    3965  292.79  3985.5  291.68  4189.5  283.38
  4416.9  282.81  4529.8  282.18  4669.2  284.56  4675.1   280.1  4690.4  284.05
  4718.6  280.04  4755.7  285.16  4798.2  284.95    4952  284.76  4973.2  282.89
  4998.9  272.04  5001.6  271.54  5004.9  272.04  5015.6  283.89  5037.3  286.05
  5599.9  291.06  5656.8  293.01    5802  301.87  5881.5   307.2  5946.2  312.28
  6093.6  322.29  6158.9   326.6    6457  345.82  6530.9  350.27  6652.3  359.35
#Mann= 20 ,-1 , 0
  3652.5     .05       0  3832.6     .08       0    3965     .05       0
  3985.5     .08       0  4189.5     .05       0  4416.9     .08       0
  4529.8     .05       0  4755.7     .16       0  4798.2     .05       0
  4998.9     .04       0  5004.9     .05       0  5599.9     .08       0
  5656.8     .05       0    5802     .08       0  5881.5     .05       0
  5946.2     .08       0  6093.6     .05       0  6158.9     .08       0
    6457     .05       0  6530.9     .08       0
Bank Sta=4952,5037.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,23815   ,1093,1093,1093
BEGIN DESCRIPTION:
PIN OAK CREEK 29.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605698.98     10669736.18      3606511.48     10668333.39
      3607323.93     10667125.14
#Sta/Elev= 30
  3502.1  324.33  3602.1  315.67  3823.7  300.15  3885.2  296.94  4124.8   288.8
  4171.2  288.29    4238  286.71  4268.7  284.02  4943.9  285.44  4948.8   285.4
  4970.4  282.44  4983.1  271.84  4985.9  271.34  4989.1  271.84  4999.8   272.8
  5007.6  283.28  5029.2  285.32  5042.4  284.99    5152  285.32  5269.5  286.55
  5375.2  287.98  5607.9  295.44  5845.2  310.16  5905.2  314.78  6075.4     327
  6093.5  328.29  6315.8  346.39  6384.8  351.92  6559.5  357.54  6579.2  358.28
#Mann= 20 ,-1 , 0
  3502.1     .12       0  3602.1     .05       0  3823.7     .08       0
  3885.2     .05       0  4124.8     .12       0  4171.2     .08       0
    4238     .12       0  4943.9     .12       0  4983.1     .07       0
  4989.1     .12       0  5042.4     .05       0    5152     .12       0
  5269.5     .05       0  5375.2     .16       0  5845.2     .05       0
  5905.2     .16       0  6075.4     .05       0  6093.5     .16       0
  6315.8     .08       0  6559.5     .05       0
Bank Sta=4948.8,5029.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,22722   ,1225,1225,1225
BEGIN DESCRIPTION:
PIN OAK CREEK 28.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606299.62     10669560.18      3606999.61     10669010.19
      3607799.64     10668760.18
#Sta/Elev= 30
  4122.7  309.49  4357.5  290.81  4487.4  284.13  4506.8  283.32  4514.9  279.27
  4521.3   283.2  4535.7  277.25  4542.4  282.71  4556.2  281.67  4707.4  282.68
  4742.7  278.73  4757.1  282.69  4792.4  279.89  4827.6  283.08    4956  283.44
  4970.4  275.29  4991.2  274.82  4996.3  271.84  4999.1  271.34  5002.3  271.84
  5015.5  272.03  5044.3  284.04  5091.2  283.31  5322.8  287.21  5379.6  288.84
  5396.9  285.65  5427.7  288.64  5670.6  300.33  5713.3  304.37  5851.1  317.94
#Mann= 11 ,-1 , 0
  4122.7     .16       0  4357.5     .12       0  4487.4     .16       0
  4556.2     .12       0  4996.3     .07       0  5002.3     .12       0
  5091.2     .16       0  5322.8     .12       0  5427.7     .16       0
  5670.6     .05       0  5713.3     .16       0
Bank Sta=4956,5044.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,21497   ,629,629,629
BEGIN DESCRIPTION:
PIN OAK CREEK 26.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606855.99     10670111.62      3607571.84     10669545.08
      3608145.64     10668493.45
#Sta/Elev= 30
  4230.6  302.21  4255.7  300.61  4270.1  295.85  4311.8  293.38  4326.2  289.94
  4421.8  285.12  4620.1  283.97  4725.3  281.15  4760.5  282.23  4789.4  280.12
  4847.1  282.11  4967.3  280.41  4981.7  273.25  4988.1  272.61  4993.2  268.72
  4995.9  268.22  4999.2  268.72    5017  271.52    5025  282.25  5081.1  281.03
  5183.3  282.77  5271.6   287.9  5315.8  293.36  5527.9  306.57  5647.5  310.37
  5898.1  325.83  6088.9  322.29  6126.8  323.92  6257.8  322.53  6341.5  325.61
#Mann= 6 ,-1 , 0
  4230.6     .12       0  4421.8     .05       0  4620.1     .12       0
  4993.2     .07       0  4999.2     .12       0  5315.8     .16       0
Bank Sta=4967.3,5025
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,20868   ,490,490,490
BEGIN DESCRIPTION:
PIN OAK CREEK 25.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607249.61     10670660.19      3607849.61     10670010.19
      3608349.61     10669510.18
#Sta/Elev= 30
  4109.7  325.54  4145.1  320.54  4166.1  319.23  4258.5  308.25  4378.8  291.31
  4480.3  283.21    4639  279.42  4668.5  279.31  4690.1   280.8  4707.7  280.09
  4845.4  279.57  4958.8  281.19    4973   280.8  4980.4  274.19  4987.2   272.9
  4987.9  268.89  4990.6  268.39  4993.9  268.89  5008.4  269.41  5022.6  272.46
  5050.9  281.17  5093.3  280.47  5107.4   278.3  5121.6  280.06  5203.1  281.76
  5347.8  285.15  5404.4  288.27  5588.3  304.13  5630.7  309.09  5701.4  312.79
#Mann= 7 ,-1 , 0
  4109.7     .16       0  4480.3     .05       0    4639     .16       0
  4707.7     .12       0  4987.9     .07       0  4993.9     .12       0
  5203.1     .16       0
Bank Sta=4958.8,5050.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,20378   ,777,777,777
BEGIN DESCRIPTION:
PIN OAK CREEK 24.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607440.04     10670953.74       3608259.5     10670175.94
      3608662.28     10669460.67
#Sta/Elev= 30
  4218.2  325.51  4298.3  320.37  4305.2  318.52  4326.7  319.17  4361.9  314.17
  4469.8  304.31    4597  292.82    4751  283.21  4892.8  279.73  4970.2  278.77
  4977.1  278.32  4991.3  273.38  4995.5   267.4  4998.3   266.9  5001.5   267.4
  5033.8  279.69  5098.3  280.29  5210.5  279.32  5246.1  275.45    5253  275.49
  5260.3  279.63  5267.2  279.77  5288.6  277.79  5630.4  281.19  5733.4   285.1
  5801.6  294.37  5888.3  301.36    5917  300.79  5990.9  304.07  6168.9  315.41
#Mann= 8 ,-1 , 0
  4218.2     .05       0  4469.8     .16       0    4597     .05       0
  4892.8     .16       0  4995.5     .07       0  5001.5     .16       0
  5098.3     .12       0  5630.4     .16       0
Bank Sta=4970.2,5033.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,19601   ,503,503,503
BEGIN DESCRIPTION:
PIN OAK CREEK 23.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607662.28     10670995.39       3608509.5     10670641.22
      3609141.26     10669474.91
#Sta/Elev= 30
  3934.4  310.56  4050.7  302.06  4105.4   295.3    4267  283.01    4581  277.62
  4646.9  279.24  4679.4   277.8  4685.8  275.57  4709.6  278.68  4748.9  278.17
  4853.9  277.68  4948.9  279.07    4979  276.85    4987  273.29  4992.7  267.71
  4998.7  267.18  5001.4  266.68  5004.7  267.18  5024.4  279.09  5399.8  282.68
  5631.8  285.97  5707.9  288.65  5789.7  289.26  5820.5  286.97  5865.8  289.55
  5893.3  288.51  5909.5  292.86  5915.2  288.94  5945.6  295.72  6179.1  308.42
#Mann= 9 ,-1 , 0
  3934.4     .16       0  4105.4     .05       0    4581     .16       0
  4748.9     .07       0  4853.9     .12       0  4998.7     .07       0
  5004.7     .12       0  5399.8     .16       0  5631.8     .12       0
Bank Sta=4948.9,5024.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,19098   ,636,636,636
BEGIN DESCRIPTION:
PIN OAK CREEK 22.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3607401.91     10671162.48      3609516.18     10670717.94
#Sta/Elev= 30
  3759.2  326.11  3797.5  325.43  3899.9  316.42  3938.1  310.38  3943.2  312.55
    3951  311.98  4037.8  304.43  4082.5   298.2  4126.9  295.37  4339.3  282.69
  4476.5  279.19  4884.3  276.79  4972.9  278.48  4983.1  275.04  4993.3  267.97
  5000.5  267.25  5003.3  266.75  5006.5  267.25  5009.1  272.64    5024  277.75
  5034.2  277.93  5238.6  277.27  5279.4  281.82  5293.1  280.07  5371.4  283.68
  5505.9  295.17  5508.1  295.44  5708.6  313.98  5791.4  319.46  5919.7  332.64
#Mann= 10 ,-1 , 0
  3759.2     .05       0  3797.5     .16       0  4126.9     .05       0
  4476.5     .16       0  4884.3     .12       0  5000.5     .07       0
  5006.5     .12       0  5293.1     .16       0  5505.9     .12       0
  5508.1     .16       0
Bank Sta=4972.9,5034.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,18462   ,374,374,374
BEGIN DESCRIPTION:
PIN OAK CREEK 21.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607849.61     10671710.19      3608649.61     10671310.19
      3609449.59      10670810.2
#Sta/Elev= 30
    4103  305.43  4200.8  298.37  4312.6  285.23  4361.8  281.87  4446.8   277.3
  4545.5  276.37  4700.4  276.18  4748.9  276.27    4908  276.63  4938.7  274.99
  4944.3  276.48  4961.1  274.43  4966.7  277.04  4975.1  277.58  4983.4   277.2
    4989  274.71  4994.6  265.93    5008  265.86  5010.7  265.36    5014  265.86
  5026.3  275.03  5032.8  276.99    5161  276.71    5294   278.5  5440.2  288.68
  5446.1  287.87  5555.8  294.08  5723.2  308.19  5838.8  315.52  5940.8  326.18
#Mann= 8 ,-1 , 0
    4103     .16       0  4361.8     .05       0  4545.5     .16       0
  4700.4     .05       0  4748.9     .12       0    5008     .07       0
    5014     .12       0    5161     .16       0
Bank Sta=4975.1,5032.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,18088   ,893,893,893
BEGIN DESCRIPTION:
PIN OAK CREEK 20.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3607640.59     10672073.94      3609713.04     10671292.71
#Sta/Elev= 30
  3803.7  323.58    3919  319.89  3969.3  312.62  4024.3  307.67  4054.6  303.41
    4115  299.54  4164.7  292.69  4200.2  291.11  4225.1  287.11  4280.2  281.43
  4403.2  277.71  4505.8  274.88  4754.6  274.91  4962.3  277.19  4978.2  276.57
  4987.2  265.86  4996.6  264.49  4999.3  263.99  5002.6  264.49  5010.3  272.44
  5017.4  275.66  5042.3  276.26  5095.2  275.52  5117.1  274.58  5288.1  279.68
  5418.3  290.63  5662.2  310.03  5699.6  314.18  5870.1  325.42  6018.5  337.99
#Mann= 8 ,-1 , 0
  3803.7     .05       0    3919     .16       0  4403.2     .05       0
  4754.6     .12       0  4996.6     .07       0  5002.6     .12       0
  5095.2     .05       0  5418.3     .16       0
Bank Sta=4962.3,5042.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,17195   ,1574,1574,1574
BEGIN DESCRIPTION:
PIN OAK CREEK 19.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608449.63     10673010.16      3608949.61     10672210.19
      3609749.64     10671610.17
#Sta/Elev= 30
  4077.8     311    4122  309.62  4212.7  300.58  4331.9  288.37  4438.4  281.75
  4666.8  274.51  4786.1  273.79  4817.9  273.99  4861.4  274.05  4867.9   269.8
  4876.7  272.21  4962.2  275.77  4976.9  273.77  4985.8  269.34  4989.3  263.66
    4992  263.16  4995.3  263.66  5013.5  271.08  5018.2  275.23    5146  273.24
  5151.1  273.29  5273.4  275.09  5306.5  275.05  5394.3  279.26  5463.9   283.4
  5599.3   297.3  5713.9  306.21  5849.3  319.36  5957.6  332.39  6021.2   337.3
#Mann= 12 ,-1 , 0
  4077.8     .05       0  4212.7     .16       0  4438.4     .05       0
  4786.1     .16       0  4817.9     .12       0  4989.3     .07       0
  4995.3     .12       0    5146     .05       0  5151.1     .12       0
  5273.4     .16       0  5306.5     .05       0  5394.3     .16       0
Bank Sta=4962.2,5018.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,15621   ,1134,1134,1134
BEGIN DESCRIPTION:
PIN OAK CREEK 17.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3608439.21     10673396.85      3610800.34     10672445.46
#Sta/Elev= 30
  3898.1  315.94  3970.5  314.42  4103.4  309.89  4157.3  304.59  4178.8  296.77
  4201.3  299.75  4308.8   287.2  4361.8  283.86  4547.8  273.29    4733  271.17
  4935.5  272.87  4965.9  273.08  4977.4  272.77  4998.6  262.32  5001.3  261.82
  5004.6  262.32  5019.8  266.38  5025.8  273.37  5031.1  273.63    5128  272.44
  5342.6  272.07    5488  275.39  5642.9  283.52    5724  290.01  5748.1  295.92
  5813.2  302.78  5921.6   310.6  6248.9  338.64    6423  356.56  6443.7  358.42
#Mann= 12 ,-1 , 0
  3898.1     .05       0  3970.5     .16       0  4361.8     .05       0
  4935.5     .12       0  4998.6     .07       0  5004.6     .12       0
    5128     .16       0    5488     .12       0  5642.9     .16       0
  5813.2     .12       0  5921.6     .16       0    6423     .12       0
Bank Sta=4965.9,5031.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,14487   ,529,529,529
BEGIN DESCRIPTION:
PIN OAK CREEK 15.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608999.59      10674260.2      3609799.61     10673660.19
      3610599.61     10672860.18
#Sta/Elev= 30
  3975.4  297.19  4047.3  291.25    4249  281.38    4289  280.54  4397.3  273.48
  4632.7  267.88  4855.6  271.73  4918.1  272.83    4979   271.9  5000.7  260.95
  5003.5  260.45  5006.7  260.95  5017.8   262.4    5032  268.24  5046.1  271.16
  5060.3  268.53  5088.6  271.17  5094.3  270.29  5102.7     269  5116.8  269.16
  5147.1  272.32  5187.6  272.31  5280.5  275.47  5406.2  276.06  5611.8  283.95
  5668.4  288.23  5710.4  294.32  5795.7  301.98  5922.9   308.7  6106.8  324.89
#Mann= 10 ,-1 , 0
  3975.4     .16       0    4249     .05       0  4855.6     .12       0
  5000.7     .07       0  5006.7     .12       0  5094.3     .16       0
  5147.1     .05       0  5280.5     .16       0  5406.2     .12       0
  5710.4     .16       0
Bank Sta=4918.1,5147.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,13958   ,536,536,536
BEGIN DESCRIPTION:
PIN OAK CREEK 14.0
END DESCRIPTION:
XS GIS Cut Line= 3
       3609099.6     10674360.19      3609899.61     10674060.19
      3610499.64     10673860.18
#Sta/Elev= 30
  4175.5  291.88  4187.9  291.33  4336.6  280.28  4393.8  277.69  4416.7  274.96
  4463.9  272.99  4634.8  268.57  4752.2  267.59  4837.7  268.28  4954.2   271.4
  4959.6  271.52  4976.5  270.52  4984.5  266.61  4986.9  261.05  4989.6  260.55
  4992.9  261.05  5008.6  264.69  5014.8  269.34  5040.5  271.44  5061.5  270.54
  5082.6  271.08  5103.7  269.72  5162.7  270.18    5204  270.09  5251.3   271.3
  5293.4  274.99    5304  276.82  5409.4   285.1  5525.3  298.28  5662.4  309.24
#Mann= 8 ,-1 , 0
  4175.5     .05       0  4187.9     .16       0  4393.8     .05       0
  4954.2     .12       0  4986.9     .07       0  4992.9     .12       0
  5162.7     .05       0    5204     .16       0
Bank Sta=4959.6,5040.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,13422   ,894,894,894
BEGIN DESCRIPTION:
PIN OAK CREEK 13.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608904.46     10674382.97      3610244.75     10674382.97
      3611321.15     10674320.47
#Sta/Elev= 30
    3905  308.08  3960.1  299.51  3990.1  300.28  4020.1  296.44  4090.1  293.69
  4148.2  289.04  4349.8  272.32  4490.1   268.2  4600.1  267.62  4893.8  271.24
  4950.1  270.12  4980.1  271.34  4997.1  261.43  4999.9  260.93  5003.1  261.43
  5010.1  262.06  5030.1  270.51  5100.1  269.43  5248.4  272.64  5310.3  274.03
  5500.6  283.12    5771  297.95  5861.2     305  5980.4  316.82  6043.2  321.13
  6101.6  324.14  6142.6  323.63  6181.7  321.26  6244.5  320.94  6323.5  318.03
#Mann= 10 ,-1 , 0
    3905     .05       0  4148.2     .16       0  4349.8     .05       0
  4893.8     .12       0  4997.1     .07       0  5003.1     .12       0
  5248.4     .16       0  5980.4     .12       0  6043.2     .16       0
  6142.6     .12       0
Bank Sta=4980.1,5030.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,12528   ,519,519,519
BEGIN DESCRIPTION:
PIN OAK CREEK 12.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608949.65     10674510.21      3609749.61     10674860.19
      3610549.57     10675510.16
#Sta/Elev= 30
  4116.9  304.31  4211.5  295.19  4306.4  288.04  4442.8  278.61    4488  276.59
  4527.3  271.78  4556.2  270.66  4695.4  268.86  4761.4   269.6  4802.8  269.79
  4934.7  268.95  4968.2  269.51  4975.6  267.73  4981.1  262.82  4987.3  259.91
  4994.3  259.19    4997  258.69  5000.3  259.19  5011.6  262.26  5018.1   269.6
  5331.2  267.68  5395.2   267.5  5564.4  273.44    5673  279.07  5717.8  285.38
  5836.1  296.13    5865     300  5881.2   300.4  5959.7  308.95  6020.8  315.23
#Mann= 15 ,-1 , 0
  4116.9     .16       0  4211.5     .05       0  4306.4     .16       0
  4442.8     .05       0  4761.4     .08       0  4802.8     .05       0
  4934.7     .12       0  4994.3     .07       0  5000.3     .12       0
  5331.2     .16       0  5564.4     .05       0  5717.8     .16       0
  5836.1     .05       0  5881.2     .12       0  5959.7     .16       0
Bank Sta=4968.2,5018.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,12009   ,607,607,607
BEGIN DESCRIPTION:
PIN OAK CREEK 11.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3608660.55     10675022.63       3610500.8      10675612.9
#Sta/Elev= 30
  4010.9  317.09  4072.9  319.29  4118.8   314.4  4125.4  312.52  4242.4  300.37
  4546.9  277.33    4605  271.66  4755.5  266.54  4912.8   266.7  4944.6  266.69
  4976.1   269.2  4986.6   266.8  4996.7  258.95  5004.6  258.76  5007.3  258.26
  5010.6  258.76  5015.5  261.13    5034  267.84  5039.3  266.49  5071.4  268.73
  5144.1  266.24  5263.4   268.8  5426.4  274.92  5543.5  279.68  5585.2  280.94
  5749.6   294.4  5813.8  299.69  5868.7  306.32  5926.1  309.74  5943.5  310.34
#Mann= 13 ,-1 , 0
  4010.9     .16       0  4242.4     .12       0    4605     .05       0
  4912.8     .07       0  5004.6     .07       0  5010.6     .07       0
  5015.5     .12       0  5263.4     .16       0  5426.4     .05       0
  5543.5     .16       0  5749.6     .05       0  5813.8     .16       0
  5926.1     .12       0
Bank Sta=4976.1,5071.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,11402   ,711,711,711
BEGIN DESCRIPTION:
PIN OAK CREEK 10.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608266.74     10675886.19      3609649.61     10675810.19
      3610449.63     10675910.19
#Sta/Elev= 30
  3613.7  320.87  3706.7  321.57  3756.8  320.54    3813  317.09    3897  307.95
    3954   304.3  3987.6  302.22  4017.2  298.41  4057.2  296.03  4277.6  276.26
  4356.8  271.72  4711.4  267.52  4748.3  266.41  4808.4  268.28  4968.6  268.39
  4988.6  257.77  4993.1   257.6  4995.9   257.1  4999.1   257.6  5001.2   257.6
  5008.7  266.71  5018.8  268.32  5089.4  266.22  5228.1  271.53  5290.9  275.04
  5391.7   277.5  5492.5   282.5  5557.3  288.95  5681.4  300.59  5804.9  315.63
#Mann= 8 ,-1 , 0
  3613.7     .05       0    3954      .1       0  3987.6     .16       0
  4711.4     .12       0  4993.1     .07       0  4999.1     .12       0
  5228.1     .16       0  5557.3     .12       0
Bank Sta=4968.6,5018.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10691   ,558,558,558
BEGIN DESCRIPTION:
PIN OAK CREEK 9.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608949.59      10676660.2      3609649.61     10676310.19
      3610449.57      10676010.2
#Sta/Elev= 30
  4207.2  314.81  4233.5  313.22  4254.5  311.28    4333   303.2  4372.1  300.91
  4394.5  297.58  4461.6   292.3  4497.9   291.2  4506.3  289.13  4542.6  285.69
  4659.1  276.21  4824.9  265.21  4923.9  266.43  4967.5   267.4  4992.5  264.62
  4996.6  257.73  4999.4  257.23  5002.6  257.73  5011.2  257.92  5021.9  266.68
  5035.2  268.07  5182.1  265.43  5207.8  266.25  5280.3  265.44  5341.3  267.85
  5506.6  279.99  5517.6  280.16  5572.8  287.31  5804.2  310.74  5844.2  317.33
#Mann= 11 ,-1 , 0
  4207.2     .12       0  4233.5     .16       0  4254.5     .05       0
  4659.1     .16       0  4923.9     .12       0  4996.6     .07       0
  5002.6     .12       0  5207.8     .16       0  5280.3     .12       0
  5341.3     .16       0  5506.6     .12       0
Bank Sta=4967.5,5035.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10133   ,261,261,261
BEGIN DESCRIPTION:
PIN OAK CREEK 8.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608949.58     10676760.19      3609749.61     10676760.19
       3610549.6      10676010.2
#Sta/Elev= 30
    4185  317.95    4221   315.7    4325  305.21    4345  300.89    4610  280.94
    4685  276.96    4705  273.71    4725  275.13    4745  272.62    4755  273.14
    4875  265.87    4965  267.02    4975  266.83  4982.5  263.86  4988.5  263.86
  4992.1  256.08    4996  255.71  4998.7  255.21    5002  255.71  5013.1  255.74
  5020.4  263.57  5027.3  265.88  5041.5  266.72  5239.8  263.95  5402.4  267.59
  5621.7  280.65  5793.3  297.12  5897.7  309.56  5932.9  312.24  6081.6  330.91
#Mann= 7 ,-1 , 0
    4185     .12       0    4221     .16       0    4610     .12       0
    4685     .16       0    4996     .07       0    5002     .16       0
  5793.3     .12       0
Bank Sta=4965,5041.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,9872    ,636,636,636
BEGIN DESCRIPTION:
PIN OAK CREEK 7.0
END DESCRIPTION:
XS GIS Cut Line= 2
       3609139.7     10677086.27      3610875.21     10676871.07
#Sta/Elev= 30
  4319.6   297.4  4471.7  288.59  4569.3  282.84  4662.1  279.61  4695.8  277.22
  4814.3  269.48  4853.6  266.31    4893  264.94    4974  266.48  4984.6     264
  4994.6  256.18  5001.7  254.55  5004.5  254.05  5007.7  254.55  5034.9   266.3
  5086.9  265.71  5286.9  263.24  5453.7  269.83  5626.5   280.7  5649.5  281.14
  5712.5  286.47  5760.5  289.18  5841.1  297.37  5950.3  305.82  5982.1  311.25
  6012.4  314.23  6031.2  317.55  6036.2  316.96  6062.8  321.21  6068.4  323.16
#Mann= 9 ,-1 , 0
  4319.6     .12       0  4471.7     .16       0  4695.8     .05       0
  4814.3     .16       0  5001.7     .07       0  5007.7     .16       0
  5086.9     .05       0  5453.7     .16       0  5649.5     .12       0
Bank Sta=4974,5034.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,9236    ,847,847,847
BEGIN DESCRIPTION:
PIN OAK CREEK 6.0
END DESCRIPTION:
XS GIS Cut Line= 3
       3609143.2     10677596.68      3610535.57     10677541.13
      3610843.66     10677856.13
#Sta/Elev= 30
  4192.5     283  4208.9  281.04    4259   278.8    4349  270.96  4439.1  264.97
  4579.2  262.22  4759.4  262.55  4852.6  263.97  4978.5  265.56  4983.5  265.29
  4989.5  258.94  4996.5  254.04  4999.3  253.54  5002.5  254.04  5009.6  261.46
  5019.6  265.62  5043.5  264.94  5169.7  262.44  5325.4  266.58  5522.2  274.37
  5609.4  278.59    5864   297.3  5892.3  299.97  5906.4  303.27  5934.6   308.4
  5948.7  309.89  5962.9  313.61  5989.4   317.8  6012.5  321.45  6026.6  321.67
#Mann= 8 ,-1 , 0
  4192.5     .05       0  4852.6     .16       0  4996.5     .07       0
  5002.5     .16       0  5043.5     .05       0  5325.4     .16       0
  5522.2     .12       0  5989.4     .16       0
Bank Sta=4978.5,5019.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,8389    ,540,540,540
BEGIN DESCRIPTION:
PIN OAK CREEK 5.0
END DESCRIPTION:
XS GIS Cut Line= 3
       3608799.6     10677810.18      3609549.61     10678110.19
       3610349.6     10678210.19
#Sta/Elev= 30
  4157.8  295.62  4292.2  287.28  4405.5  280.69  4573.8  266.75  4696.3  260.44
  4771.7  260.08  4943.7  263.76  4975.7  264.63  4985.7  257.87  5000.4   253.8
  5003.1   253.3  5006.4   253.8    5016  264.11  5026.1  264.16  5157.1  261.74
  5217.5  264.07  5245.2  267.31  5257.8  267.18  5288.1   261.6  5321.1  261.31
  5388.9  261.16  5429.2  263.43  5492.2  268.39  5519.6  272.69    5540  276.33
  5580.3  278.75  5620.6  284.82    5671  295.45  5697.5  298.42  5771.8  306.96
#Mann= 8 ,-1 , 0
  4157.8     .12       0  4292.2     .05       0  4943.7     .16       0
  5000.4     .07       0  5006.4     .16       0  5321.1     .05       0
  5519.6     .16       0  5697.5     .05       0
#XS Ineff= 2 , 0
                         5257.95           267.2
Permanent Ineff=
       F       F
Bank Sta=4975.7,5026.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,7849    ,548,548,548
BEGIN DESCRIPTION:
PIN OAK CREEK 4.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608799.64     10677860.22      3609449.61     10678560.19
      3610249.59     10678910.18
#Sta/Elev= 30
  4049.3  295.02    4100  293.64  4188.5  288.48  4389.1  272.61  4601.1  260.67
  4686.2  259.95  4749.7  261.83  4863.1   260.8  4942.4  263.29  4962.3  264.02
  4976.4   263.8  4983.2  256.01  4987.6  253.68  4990.3  253.18  4993.6  253.68
  5007.2  254.88  5013.5  264.01  5073.6  262.47  5124.6   263.2  5170.2  260.38
  5287.1  261.94    5316  261.58  5321.4  260.09  5367.2   261.1    5434  262.72
  5659.4  274.75    5712  280.54  5717.5  279.54  5740.9   281.7  5877.7  298.91
#Mann= 9 ,-1 , 0
  4049.3     .12       0    4100     .16       0  4188.5     .05       0
  4942.4     .16       0  4987.6     .07       0  4993.6     .16       0
  5073.6     .05       0  5367.2     .16       0    5434     .05       0
Bank Sta=4962.3,5013.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,7301    ,467,467,467
BEGIN DESCRIPTION:
PIN OAK CREEK 3.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608899.62     10678560.19      3609649.61     10678960.19
      3610399.62     10678960.19
#Sta/Elev= 30
  4151.7  283.79  4187.5  282.29    4299  266.27  4351.8  261.85  4587.7  261.83
  4669.8  260.36  4675.5  261.93  4697.5  260.59  4713.8  262.45  4777.2  262.34
  4867.5  261.56  4965.9  262.86  4971.6  262.66  4987.9   253.4  4995.9  252.27
  4998.6  251.77  5001.9  252.27  5011.7  253.33  5021.7  262.94    5025  262.77
  5111.7  260.33  5341.7  272.41  5431.7  278.98  5491.7  285.49  5521.7  290.68
  5561.7  295.37  5601.7  302.82  5631.7  310.75  5691.7  319.61  5751.7  326.35
#Mann= 5 ,-1 , 0
  4151.7     .05       0  4777.2     .16       0  4995.9     .07       0
  5001.9     .16       0    5025     .05       0
Bank Sta=4965.9,5021.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,6834    ,1853,1853,1853
BEGIN DESCRIPTION:
PIN OAK CREEK 2.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607842.19     10678595.52      3609222.43     10679163.25
      3610366.48     10679168.45
#Sta/Elev= 30
  3220.1  304.46  3244.9  306.06  3452.8  304.05  3511.5   302.8  3567.6  299.35
  3636.7  294.36  3790.4  287.26  3796.7  285.21  3980.6  271.43  4049.9  268.39
  4210.5  265.68    4615  259.99  4902.8  261.05  4969.7  262.31  4979.7  257.46
  4996.7  252.16  4999.5  251.66  5002.7  252.16  5009.7  254.25  5019.7   262.3
  5173.3  260.93  5279.7  260.91  5289.7  259.37  5319.7  260.34  5449.7   272.7
  5529.7  282.42  5549.7  286.45  5629.7  295.05  5739.7  301.48  5856.6  312.42
#Mann= 7 ,-1 , 0
  3220.1     .12       0  3567.6     .16       0  4210.5     .05       0
  4902.8     .16       0  4996.7     .07       0  5002.7     .16       0
  5173.3     .05       0
Bank Sta=4969.7,5019.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4981    ,0,0,0
BEGIN DESCRIPTION:
PIN OAK CREEK 1.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3608297.35      10678920.4      3609845.98     10679989.85
      3610207.09     10679941.24      3610609.86     10679295.43
#Sta/Elev= 30
  2901.8  286.15  3220.5  271.33  3319.4  268.79  3441.8  261.98  3585.1  259.88
  4140.1  259.09    4290  260.11  4788.2  257.68  4971.4  260.39  4989.3  255.95
  4996.4  248.69  4999.1  248.19  5009.5  251.54  5019.6  259.45  5216.7   257.8
  5280.4   261.5  5478.6   278.6  5600.1  297.88  5673.2   307.2  5709.8  309.56
  5731.1  313.76  5746.4  313.69  5752.3  316.49  5767.6   317.1    5783     315
  5788.9  318.34  5804.2  316.49  5825.4  318.32  5856.1  317.92  5909.3  322.51
#Mann= 8 ,-1 , 0
  2901.8     .16       0  3220.5     .16       0  3319.4     .07       0
  4140.1     .07       0  4971.4     .03       0  5019.6     .07       0
  5216.7     .12       0  5731.1     .16       0
Bank Sta=4971.4,5019.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Chan Stop Cuts=-1
Use User Specified Reach Order=0
Composite Channel Slope=5

--- PIN OAK CREEK.g02 (geometry) ---

Geom Title=temp Existing Conditions
Program Version=4.10

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
River Reach=PIN OAK CREEK   ,Reach-1

Type RM Length L Ch R = 1 ,76480   ,407,407,407
BEGIN DESCRIPTION:
PIN OAK CREEK 133.0
END DESCRIPTION:
XS GIS Cut Line= 3
       3603149.6     10631060.19      3603649.61     10631010.19
      3603899.64     10630760.16
#Sta/Elev= 30
  4487.1  417.65  4557.5  417.22  4617.8  414.65  4647.9  414.49    4658  414.85
  4718.3  414.84  4748.4  414.67  4836.3  413.28  4841.4   413.7  4889.1  413.52
  4929.3  412.78  4941.9  413.34  4949.4  413.22  4959.4  412.81  4969.5  411.08
  4979.5  411.09  4987.1     408  4993.1     408    4997  406.18  4999.8  405.68
    5003  406.18  5003.7  406.18  5017.9  413.47  5088.6  413.21    5131  413.88
  5173.4  413.95  5187.6  414.93  5244.2  415.54  5272.4  416.54  5343.2  418.01
#Mann= 3 ,-1 , 0
  4487.1     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,76073   ,345,345,345
BEGIN DESCRIPTION:
PIN OAK CREEK 132.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603099.58      10631610.2      3603999.61     10631210.19
      3604399.59      10630960.2
#Sta/Elev= 30
  4035.3     420  4443.7  416.93  4640.6  414.61  4658.4   413.8  4832.1   412.3
    4878  409.52  4889.6  410.61  4939.2  412.05  4982.6  411.54    4997  406.15
  4999.8  405.65    5003  406.15  5005.9  406.15  5011.3  411.86  5051.2  411.02
  5064.4  409.53  5070.3  410.35  5085.7  408.57  5091.6  409.84  5106.9   408.8
  5114.6  409.56  5137.6  414.58  5201.2  416.04  5267.9     419  5303.9  421.36
  5389.9  424.12  5411.1  425.63  5420.6   425.4    5433  426.68  5491.9  429.25
#Mann= 6 ,-1 , 0
  4035.3     .05       0  4939.2     .12       0    4997     .07       0
    5003     .12       0  5051.2     .05       0  5303.9     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,75728   ,579,579,579
BEGIN DESCRIPTION:
PIN OAK CREEK 131.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603192.47     10631698.31      3604385.16     10631394.49
      3604555.31     10630802.44
#Sta/Elev= 30
    3965  421.73  3977.6  419.62  4034.3  417.59  4340.5  414.72  4447.1  415.04
  4621.6  412.48  4715.4  411.96  4818.6  410.14    4826   409.8  4834.9  407.39
  4839.2  406.83  4859.8  408.92  4890.8  410.31  4921.8  409.68  4932.1  410.58
  4973.3  410.73  4983.7  410.29  4989.6  405.21    4997  405.21  4999.8  404.71
    5003  405.21  5015.8  408.95  5045.6  411.63  5217.2  416.46  5488.5  424.64
  5585.2  427.94  5658.1  428.33  5689.3   429.7  5702.8  429.12  5811.8  429.86
#Mann= 7 ,-1 , 0
    3965     .05       0  4834.9     .12       0    4997     .07       0
    5003     .12       0  5015.8     .05       0  5217.2     .16       0
  5488.5     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,75149   ,409,409,409
BEGIN DESCRIPTION:
PIN OAK CREEK 130.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3603365.11     10632074.68      3605339.13     10631647.58
#Sta/Elev= 30
    4075  418.86  4468.4  413.49  4959.5  409.65  4967.8  408.96    4980  403.88
  4990.2  401.88    4997  401.75  4999.8  401.25    5003  401.75  5010.7  401.75
  5031.9  406.57  5041.4  408.82  5102.7  408.41  5133.4  407.08  5159.6  408.78
  5174.4  407.86  5184.6  408.91  5194.8  408.34    5253  410.46  5331.5  410.49
  5444.7  413.34  5493.9  415.79  5573.4  415.98  5582.2  414.51  5631.4  416.66
  5636.5  415.88    5645  416.69  5757.6  418.25  5880.3  421.43  6094.7  424.95
#Mann= 5 ,-1 , 0
    4075     .05       0    4997     .03       0    5003     .05       0
  5031.9     .12       0  5331.5     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,74740   ,735,735,735
BEGIN DESCRIPTION:
PIN OAK CREEK 129.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3603479.77     10632256.95      3605453.67     10631939.26
#Sta/Elev= 30
  3999.8  419.42  4019.9  416.49    4030  416.05  4198.4  413.26    4344  414.12
  4607.4  411.01    4739  410.87  4827.1   408.2  4948.4  407.82    4972   408.3
  4992.2  400.51    4997  399.98  4999.8  399.48    5003  399.98  5012.5   401.7
  5017.7  399.98  5022.7  402.94  5063.2  407.99  5103.7  405.62  5116.8  407.22
  5141.4  409.16  5217.6  409.07  5356.9  411.12  5393.9  412.87  5522.6  415.43
  5579.4  417.68  5903.9  422.58  5960.7  424.35  5965.7  423.85  5999.1  425.52
#Mann= 6 ,-1 , 0
  3999.8     .05       0  4948.4     .12       0    4997     .07       0
    5003     .12       0  5116.8     .16       0  5217.6     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,74005   ,1157,1157,1157
BEGIN DESCRIPTION:
PIN OAK CREEK 128.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603500.59     10632715.29      3604594.32     10632678.83
      3605344.32     10632319.46
#Sta/Elev= 30
  4011.4  418.06  4290.6  414.19  4410.6  413.14  4480.7  411.59  4550.7  411.24
  4580.7  409.98  4670.8  407.96  4770.8  407.37  4790.9   406.3  4906.7   406.4
  4910.4   406.4  4920.9  409.15  4940.9   409.9    4971  409.74    4991  405.49
    4997  397.05  4999.8  396.55    5003  397.05    5011  397.05    5021  404.32
    5031  406.04  5075.4  405.72  5178.1  404.96  5296.9   405.7  5387.6  407.03
  5551.7  412.03  5557.3  412.98  5579.9  413.22  5597.1  414.85  5937.4  422.55
#Mann= 5 ,-1 , 0
  4011.4     .05       0  4906.7     .16       0    4997     .07       0
    5003     .16       0  5075.4     .05       0
#XS Ineff= 2 , 0
         4934.55  409.66
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,72848   ,88,88,88
BEGIN DESCRIPTION:
PIN OAK CREEK 127.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603500.91     10632991.08      3605362.04     10633095.25
      3606181.44     10633136.91
#Sta/Elev= 30
  3262.7  419.04  3591.9  414.44  4049.8  409.94  4122.7  410.22  4212.9  408.17
    4308  409.33  4505.7   405.8  4593.7  404.12  4964.1  402.16  4974.1  401.92
  4984.1  397.66    4997  395.16  4999.8  394.66    5003  395.16  5004.1   396.6
  5014.1  398.06  5024.1  402.35  5034.2   404.4    5099  404.67    5321   412.4
  5484.8  414.66  5514.6  417.35  5519.6  416.07  5534.8  417.01  5624.9  416.06
    5791   418.9  5889.9  421.39  5911.8   422.8  5916.8  421.86  5947.2  423.01
#Mann= 8 ,-1 , 0
  3262.7     .08       0    4308     .05       0  4505.7     .08       0
    4997     .07       0    5003     .08       0    5099     .08       0
    5791     .05       0  5889.9     .08       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,72760   ,286,286,286
BEGIN DESCRIPTION:
PIN OAK CREEK 126.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3603525.78      10633104.5       3606138.7     10633208.67
#Sta/Elev= 30
    3314  418.74    3327  419.89  3357.9  420.17  3577.6  416.77  3582.6  416.02
  3828.2  413.07  3998.4   412.4  4078.4  410.27  4083.9  411.17  4108.5  411.43
  4329.9  409.13  4458.7  408.28  4618.9  404.37  4959.1  402.62  4979.2  400.81
    4997  394.43  4999.8  393.93    5003  394.43  5009.2  396.04  5019.2  402.53
  5059.2  403.66  5169.3  404.26  5336.9  409.79  5419.5  411.24  5489.6  411.16
  5587.5  413.02  5592.5  412.31  5719.7  415.46  5769.8  417.61    5929  421.12
#Mann= 4 ,-1 , 0
    3314     .05       0  4329.9     .16       0    4997     .07       0
    5003     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,72474   ,411,411,411
BEGIN DESCRIPTION:
PIN OAK CREEK 125.0
END DESCRIPTION:
XS GIS Cut Line= 5
      3603521.81     10633220.25      3605167.59     10633393.86
      3605396.76      10633400.8      3605910.65     10633407.75
      3606292.58     10633511.91
#Sta/Elev= 30
  3220.2  416.15  3449.3  410.45  3456.1  410.08  3461.1  407.02  3730.8  406.19
  3750.9  402.94  3837.8  404.43  3842.8  402.91  4022.4  409.37  4042.5  407.18
  4138.6  410.15  4144.5  410.26  4595.6  404.02  4716.3  405.57  4937.2  402.31
  4955.3  399.71  4987.2  397.29    4997  393.65  4999.8  393.15    5003  393.65
  5007.2  396.63  5037.2  397.55  5087.2  405.46  5227.7  403.53  5307.3  402.68
  5623.4  409.99  5644.9  411.01  5650.1  408.85  5886.7  414.46  6014.2  414.76
#Mann= 8 ,-1 , 0
  3220.2     .05       0  4138.6     .16       0  4144.5     .05       0
  4955.3      .1       0    4997     .07       0    5003      .1       0
  5227.7     .16       0  5623.4     .05       0
#XS Ineff= 2 , 0
                         5230.24          403.43
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,72063   ,423,423,423
BEGIN DESCRIPTION:
Mapping XS dc94abb8
END DESCRIPTION:
XS GIS Cut Line= 3
      3603904.53     10634275.97      3605412.82     10633696.53
      3605793.34     10633454.38
#Sta/Elev= 30
    3602  422.33  3633.1   421.7  3703.9  417.98    3736   415.5  3767.1   411.7
  3827.2  408.85  4021.2  403.17  4275.2  402.17  4324.5  399.81  4359.9  399.31
  4384.5  397.33  4414.5  396.33  4439.2  393.24    4997  393.24  4999.8  392.74
    5003  393.24  5056.6  393.24  5064.3  394.45  5096.5  394.97  5150.1  399.99
  5195.9  402.29    5226   405.7  5260.3   403.3  5329.3  400.58  5356.4  402.27
  5402.1  402.33  5568.9  409.54  5574.8  410.78  5644.5  413.11  5668.8  412.52
#Mann= 5 ,-1 , 0
    3602     .05       0    4997    .033       0    5003     .05       0
  5260.3      .1       0  5644.5     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,71640   ,436,436,436
BEGIN DESCRIPTION:
PIN OAK CREEK 124.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604999.62     10634960.16      3605299.61     10634160.19
      3605799.61     10633460.19
#Sta/Elev= 30
    4161  409.12  4331.9     406  4445.5  402.57  4542.8  400.58  4749.3  399.49
  4835.1  396.35  4884.5  393.24    4997  393.24  4999.8  392.74    5003  393.24
  5123.5  393.51  5165.3  398.97    5180  399.19  5209.5  395.46  5259.9  393.88
    5287  395.55  5295.6  397.27  5331.2  398.12  5352.1  397.25  5366.8  398.39
  5387.7  396.89    5432  396.37    5514  399.01  5542.7   399.7  5580.7  401.09
  5631.2  400.77  5740.4  405.61  5847.3  413.07  5865.7  413.38  5875.6  413.12
#Mann= 9 ,-1 , 0
    4161     .05       0  4445.5     .16       0  4835.1     .05       0
    4997    .033       0    5003     .05       0    5514      .1       0
  5542.7     .05       0  5631.2      .1       0  5865.7     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,71204   ,422,422,422
BEGIN DESCRIPTION:
PIN OAK CREEK 123.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605080.52     10634989.32      3605696.82     10634351.33
      3606775.39      10633935.5
#Sta/Elev= 30
  4375.7  410.95    4629  410.22  4869.5  406.62  4926.1  400.34  4968.6   393.3
    4997  391.73  4999.8  391.23    5003  391.73  5039.3   393.9  5046.2  396.23
  5060.4   398.5  5095.9  400.51  5131.1  403.98  5237.1  407.01  5319.3  399.85
    5330  399.73  5340.8   397.6  5383.6  395.21  5395.4  392.88  6080.3  392.88
  6091.2  395.15  6110.4  396.48  6115.8   398.3    6165  400.79  6170.4  402.53
  6219.6  404.65  6230.3  406.62  6279.6  408.77  6316.1  413.19  6418.7  421.57
#Mann= 3 ,-1 , 0
  4375.7     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,70782   ,450,450,450
BEGIN DESCRIPTION:
PIN OAK CREEK 122.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3604994.44     10635176.83      3605402.42     10634920.76
      3605810.41     10634920.76      3607580.53     10634958.97
#Sta/Elev= 30
  4307.6  414.33  4382.3  415.07  4715.1  413.62  4836.5  409.81  4946.5  394.85
    4997  390.27  4999.8  389.77    5003  390.27  5194.4  400.88  5246.5  402.23
  5286.5  401.32  5346.5  402.48  5416.5  405.87  5506.5  406.93  5636.6  405.42
  5676.6  403.29  5726.6  398.28  5756.6   397.3  5816.6  392.88  6706.8  392.88
  6726.8   395.4  6736.8   398.1  6766.8  400.72  6792.2  404.42  6816.8  405.33
  6846.9   409.8  6856.9  410.14  6876.9  407.58  6906.9  410.23  6967.8  411.91
#Mann= 3 ,-1 , 0
  4307.6     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
