HEC-RAS study PIN OAK CREEK.prj: PIN OAK CREEK Base Level Engineering

--- PIN OAK CREEK.g02 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,70332   ,474,474,474
BEGIN DESCRIPTION:
PIN OAK CREEK 121.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605042.14     10635354.79      3606161.97     10635385.17
      3609344.27     10635366.79
#Sta/Elev= 30
  4442.3  419.82  4659.9  419.81  4789.9  414.84    4930  395.91    4960  389.91
    4997  387.67  4999.8  387.17    5003  387.67    5170  401.98  5500.2   413.5
  5650.2  410.41  5770.2   398.1  5970.2  402.37  6030.2  392.88  7110.2  392.88
  7170.2  401.78  7240.2  407.81  7260.2  412.78    7288  410.65  7310.2  413.64
  7350.2  414.21  7410.2   411.2  7440.2  415.59  7524.7  419.29  7635.9  423.13
  7690.2  425.98  7829.5  427.69  8150.2  435.81  8490.2  449.17  8744.9  452.87
#Mann= 6 ,-1 , 0
  4442.3     .05       0    4997     .03       0    5003     .05       0
  7524.7     .16       0  7635.9     .08       0  7829.5     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,69858   ,392,392,392
BEGIN DESCRIPTION:
PIN OAK CREEK 120.0
END DESCRIPTION:
XS GIS Cut Line= 5
      3605003.16     10635853.92      3606140.27     10635827.88
      3607178.46     10637072.52      3607100.79      10640887.8
      3608411.58     10641703.79
#Sta/Elev= 30
  4431.7  422.73  4758.2  417.83    4997  385.28  4999.8  384.78    5003  385.28
  5068.3  395.34  5148.3  401.29  5428.4   409.3  5585.1  410.31  5868.8   399.5
  6181.2  403.08  6699.2  420.93  7247.6  420.32  8137.8  430.08  8627.9  424.61
    9438  425.67  9538.1  417.16  9839.5  422.75 10258.2  420.73 10518.3  425.11
 10758.3  393.88 10908.3  412.21 11240.2  399.31   11551  397.05 11739.9  400.54
 11855.6  411.79 12052.9  418.12 12452.8  422.07 12495.3  432.34   12550  434.34
#Mann= 3 ,-1 , 0
  4431.7     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,69466   ,481,481,481
BEGIN DESCRIPTION:
PIN OAK CREEK 119.0
END DESCRIPTION:
XS GIS Cut Line= 5
      3605089.97     10636218.51      3606075.16     10636235.87
      3607140.58     10637092.95      3607065.06     10640935.62
      3608414.76     10641777.56
#Sta/Elev= 30
  4575.8  419.77  4785.5  413.32    4997  384.43  4999.8  383.93    5003  384.43
  5215.5  401.54  5695.2  407.45    5909  400.63  6203.2  408.77    6208  409.03
  6396.3  416.63  6455.7     417  6576.7  418.51    6672  418.78  7573.8  430.61
  7583.4  430.79  9186.2  426.61  9264.6  419.02  9526.3  427.34  9846.3  421.15
 10206.4  425.75 10486.4  393.83 10626.5  413.03 10996.6  399.71 11374.1  398.34
 11519.8  401.12 11657.2  414.11 12229.4  421.28   12266  430.06 12362.7   435.4
#Mann= 11 ,-1 , 0
  4575.8     .05       0    4997     .03       0    5003     .05       0
  6203.2     .08       0    6208     .05       0  6396.3     .08       0
  6455.7     .05       0  6576.7     .08       0    6672     .05       0
  7573.8     .08       0  7583.4     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,68985   ,383,383,383
BEGIN DESCRIPTION:
PIN OAK CREEK 118.0
END DESCRIPTION:
XS GIS Cut Line= 5
      3604998.76     10636687.26      3606083.84      10636691.6
      3607101.13     10637124.45      3607022.86     10640967.76
      3608413.79     10641825.72
#Sta/Elev= 30
  4578.4   415.5  4859.3  405.68    4997  383.84  4999.8  383.34    5003  383.84
  5013.1  384.71  5042.8   385.6  5169.3  400.34  5389.3  398.86  5821.2  406.85
    6003  402.51  6245.7  412.95  7064.8   431.4  7392.1  431.68  7493.4   432.2
    7995  432.74  8835.2  424.69  9345.3  426.29  9555.4  420.27 10033.4  424.02
 10285.5  393.78 10445.5   414.4 10758.4   400.8 11274.1  399.27 11384.1  401.73
 11557.9  414.78 11878.3  422.84 12088.9  420.46 12131.5  430.51 12247.4  435.66
#Mann= 7 ,-1 , 0
  4578.4     .05       0    4997     .03       0    5003     .05       0
  5013.1     .08       0  5042.8     .05       0  7392.1     .08       0
  7493.4     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,68602   ,577,577,577
BEGIN DESCRIPTION:
PIN OAK CREEK 117.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3604894.67     10637055.64      3606036.52     10637065.48
      3607041.67     10637446.93      3606971.66     10640995.65
#Sta/Elev= 30
  4523.3   413.1  4758.2  408.12  4898.3  396.57  4958.3  386.23    4997  383.64
  4999.8  383.14    5003  383.64  5048.3  384.69  5118.3   395.2  5208.3  402.41
  5478.3  398.66  5894.1  407.77  6058.9  402.88  6331.6  416.86  6624.2  422.57
  6773.6  429.72  7053.4  429.06  7086.9  429.51  7733.7  431.73  8373.9  419.33
    8894  425.04    9184  419.24  9414.1  422.68  9614.1  420.56  9754.1  414.16
  9924.2  395.35  9974.2  397.78 10094.2  415.04 10154.2  416.64 10289.7  410.67
#Mann= 5 ,-1 , 0
  4523.3     .05       0    4997     .03       0    5003     .05       0
  7053.4     .08       0  7086.9     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,68025   ,504,504,504
BEGIN DESCRIPTION:
PIN OAK CREEK 116.0
END DESCRIPTION:
XS GIS Cut Line= 6
      3604746.93     10637346.01      3605155.49     10637611.82
      3605342.52     10637611.82      3606085.74      10637405.1
      3606962.27     10637688.83       3606950.3     10641010.01
#Sta/Elev= 30
  4428.5  410.89  4773.5  402.59    4846  387.46    4852  383.85    4997  378.89
  4999.8  378.39    5003  378.89  5126.8   393.5  5214.1  397.76  5318.7  397.54
    5567  388.84  5905.9   405.4  6001.9  406.91  6172.8  400.73  6268.5  401.77
    6446  414.75  6817.1  427.61  7357.1  426.36  7587.1  429.67  8147.1  416.81
  8617.1   423.3  8967.1  419.26  9157.1  421.61  9547.1  412.25  9737.1  393.41
  9767.1  395.01  9897.1  413.92  9937.1  416.76  9997.1  417.04 10116.9  410.96
#Mann= 3 ,-1 , 0
  4428.5     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,67521   ,434,434,434
BEGIN DESCRIPTION:
PIN OAK CREEK 115.0
END DESCRIPTION:
XS GIS Cut Line= 5
      3604781.43     10638118.78      3605642.76     10638104.02
       3606199.6     10638692.82      3606897.52     10638791.78
      3606866.27     10641000.09
#Sta/Elev= 30
    4512  415.97  4830.2  400.97    4997   377.6  4999.8   377.1    5003   377.6
  5160.3   398.6  5220.3  403.84  5310.3  407.62    5503  406.56  5785.8  394.21
  6019.2   399.3  6186.4  399.37  6315.2  389.25  6375.8  390.78  6426.3  397.48
  6567.7  407.45  6587.9   411.2  6887.3     420  7027.2  414.88  7207.2  412.97
  7567.2  421.98  7917.3  418.83  8077.3  420.95  8277.3  409.33    8505  403.02
    8510  400.97  8677.4  391.99  8937.4   419.3  8997.4  419.57  9097.3  413.69
#Mann= 3 ,-1 , 0
    4512     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,67087   ,501,501,501
BEGIN DESCRIPTION:
PIN OAK CREEK 114.0
END DESCRIPTION:
XS GIS Cut Line= 5
      3604943.85     10638542.07      3605608.31     10638542.07
      3606241.27     10639015.74       3606637.1     10639109.49
      3606803.79     10639187.62
#Sta/Elev= 30
  4654.7  417.01  4720.5  412.62  4800.5  403.75    4997  376.59  4999.8  376.09
    5003  376.59  5020.5  376.69  5090.5  387.13  5210.5  399.36  5260.5  402.18
  5340.3  404.51  5619.5  396.81  5969.7   401.5  6075.9  398.87  6096.8  397.24
  6128.6  393.05  6138.9  392.75  6159.4  389.42    6180  388.89  6200.5  390.07
    6293  390.68  6363.7  397.53  6411.1  400.81  6416.3  402.22  6447.2  404.68
  6467.7  408.66  6488.3  407.41  6550.2  411.13  6578.5  410.97  6700.6   414.8
#Mann= 3 ,-1 , 0
  4654.7     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,66586   ,393,393,393
BEGIN DESCRIPTION:
PIN OAK CREEK 113.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604849.58     10638610.15      3605149.61     10638960.19
      3605299.64     10639110.22
#Sta/Elev= 30
  4559.2   421.2  4562.5   421.2  4580.7  418.76  4644.3  412.62  4672.8   409.3
  4679.4  409.09  4701.4  406.59  4715.7  405.61  4779.3  397.72  4828.7  393.83
  4835.8   392.5  4849.6  391.39  4857.2  389.91    4900  386.07  4914.3  383.49
    4928  382.19  4935.2  380.36  4941.8  379.41    4978  376.04    4997  375.79
  4999.8  375.29    5003  375.79  5023.8  376.02  5062.7  378.45  5076.8  379.99
  5119.2   382.7  5133.4  384.41  5147.5  384.98  5189.9  389.36  5232.4  392.86
#Mann= 3 ,-1 , 0
  4559.2     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,66193   ,460,460,460
BEGIN DESCRIPTION:
PIN OAK CREEK 112.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604649.61      10638810.2      3604849.61     10639210.19
      3605149.58     10639310.18
#Sta/Elev= 30
  4548.4  414.01  4562.4     413  4601.5  408.07  4668.6   400.8  4682.6  399.98
  4696.5  397.67  4704.9  397.39    4758  391.32  4794.4  388.13  4825.1  383.78
  4861.4  380.86  4869.8  379.41  4883.8  379.03  4928.5   375.8  4942.5  375.73
  4950.9  376.55  4964.9   375.8  4981.6  376.18  4992.8  374.34    4997  374.34
  4999.8  373.84    5003  374.34  5016.7  374.86  5027.2  376.09  5069.4  375.66
    5101  377.23  5111.6  378.47  5132.6  379.08  5185.3  383.02  5311.8  389.53
#Mann= 3 ,-1 , 0
  4548.4     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,65733   ,485,485,485
BEGIN DESCRIPTION:
PIN OAK CREEK 111.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604249.58     10639160.16      3604499.61     10639410.19
      3604999.62      10640160.2
#Sta/Elev= 30
    4629  400.55  4643.2  401.75  4657.3  398.09  4756.3  391.08  4784.6  388.06
  4883.6  380.45  4911.9     377  4954.3  374.82    4997  374.36  4999.8  373.86
    5003  374.36  5018.7  375.33  5113.3  374.41  5227.5  378.31  5350.7  379.55
  5428.8  381.91  5443.8  381.55  5473.9  378.16  5494.9  377.11  5530.9  376.93
    5552  377.65    5567  379.82    5588  381.21  5595.5  382.74  5660.1   387.4
  5681.2  390.09  5717.2  392.91  5753.3  394.91  5783.3  395.05    5884  399.89
#Mann= 3 ,-1 , 0
    4629     .05       0    4997     .03       0    5003     .05       0
#XS Ineff= 2 , 0
                         5443.98          381.56
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,65248   ,438,438,438
BEGIN DESCRIPTION:
PIN OAK CREEK 110.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604099.61      10639310.2      3604149.61     10639660.19
      3604099.61     10640110.18
#Sta/Elev= 30
  4623.4  392.54    4684  389.98  4694.1  388.92  4714.3     388  4754.7  386.86
  4875.9  379.39    4886  378.02  4916.3  376.97  4946.6  374.64  4966.8  373.91
  4979.5  373.94    4987   373.2    4997  373.18  4999.8  372.68    5003  373.18
  5047.4  374.21  5057.4  375.13  5067.5  375.25  5077.6  376.32  5107.7  377.54
  5137.9  379.48  5168.1  380.41  5198.3  382.07  5218.4  382.55  5248.6   384.2
  5288.8  385.71  5298.9  385.53  5379.4  387.39  5409.6  387.14  5429.7  387.87
#Mann= 3 ,-1 , 0
  4623.4     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,64810   ,425,425,425
BEGIN DESCRIPTION:
PIN OAK CREEK 109.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603499.65      10639810.2      3603799.61     10639910.19
      3604049.58     10640160.16
#Sta/Elev= 30
  4661.9  397.47  4714.6  393.18  4725.1  392.62  4746.2   390.4  4756.7  389.98
  4809.4  385.36    4820     385  4841.1  382.97  4862.1  381.77  4872.7  380.14
  4893.8   378.7  4914.8  376.46  4975.4  372.69  4981.6  372.69  4992.2  371.82
    4997  371.82  4999.8  371.32    5003  371.82  5020.5  372.79  5077.1  373.41
  5091.2  374.34  5105.4   374.4  5133.6  375.58  5204.4  380.25  5260.9  383.24
  5275.1  384.72  5289.2  385.39  5303.4  386.67  5317.5  387.04  5331.6  387.98
#Mann= 3 ,-1 , 0
  4661.9     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,64385   ,452,452,452
BEGIN DESCRIPTION:
PIN OAK CREEK 108.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603349.63      10640060.2      3603649.61     10640310.19
      3603899.57     10640360.18
#Sta/Elev= 30
    4602  401.13  4615.6   400.2    4630  398.36  4644.3   397.9  4666.4  394.91
  4672.9  394.96  4687.2  392.93  4693.7  393.08  4722.4  389.98  4736.7  389.34
  4765.3  386.05  4779.7  385.34    4794   383.2    4850  379.02  4857.8  377.89
  4872.1  377.16  4886.4  375.35  4935.9  372.32  4964.5  372.21    4971  371.45
    4995   372.1    4997  371.45  4999.8  370.95    5003  371.45  5023.1  372.91
  5033.3     373  5084.3  377.85  5114.9  379.31  5125.1  380.86  5247.4  387.03
#Mann= 3 ,-1 , 0
    4602     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,63933   ,446,446,446
BEGIN DESCRIPTION:
PIN OAK CREEK 107.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603199.64      10640560.2      3603399.61     10640660.19
      3603899.63     10640660.19
#Sta/Elev= 30
  4786.6  387.94  4822.9  385.14  4831.3  383.88  4839.7  383.47  4845.3  381.98
  4853.7  381.46    4862  379.23    4876  378.06    4890  375.17  4929.1  371.77
  4957.1  371.25  4973.8  371.73  4979.4  372.61    4997  371.18  4999.8  370.68
    5003  371.18  5040.2  372.15  5050.2  372.78  5070.2  372.96  5150.2  371.87
  5200.2  372.03  5220.2  374.05  5260.2  376.59  5290.2  377.86  5300.2   378.8
  5320.2  379.83  5360.2  380.76  5480.2  386.79  5500.2  388.56  5510.2  388.88
#Mann= 3 ,-1 , 0
  4786.6     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,63487   ,407,407,407
BEGIN DESCRIPTION:
PIN OAK CREEK 106.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3602949.63      10640860.2      3603149.61     10641010.19
      3603749.63     10641010.19
#Sta/Elev= 30
  4731.2  388.46  4759.3  387.48  4773.9  385.55  4817.6  383.16  4844.7  380.98
  4867.6  380.22  4888.5  377.89  4909.3  374.33  4923.9  372.76  4931.2  370.32
  4944.7  369.72    4997   369.5  4999.8     369    5003   369.5  5011.2  370.25
  5021.2  370.35  5081.2  378.25  5101.2  378.43  5131.2  380.02  5191.2  381.17
  5241.2   380.1  5251.2  379.48  5271.2  376.14  5281.2  373.95  5301.2  372.58
  5361.2  373.86  5391.2  375.54  5411.2  377.46  5471.2  380.93  5581.2  384.53
#Mann= 3 ,-1 , 0
  4731.2     .05       0    4997     .03       0    5003     .05       0
#XS Ineff= 2 , 0
                          5260.8          377.67
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,63080   ,504,504,504
BEGIN DESCRIPTION:
PIN OAK CREEK 105.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3602599.64     10641160.21      3602999.61     10641360.19
      3603549.64      10641510.2
#Sta/Elev= 30
  4563.3  389.89    4689  383.59  4711.4  382.23  4719.8  381.05  4756.1  379.48
  4817.6  375.31    4854  373.96  4862.3  372.67  4898.7  371.37  4929.4  369.05
  4957.4  368.17    4997  368.15  4999.8  367.65    5003  368.15  5051.9  368.45
    5083  369.62    5102  371.82  5107.2  371.63  5141.8   374.2    5147  373.89
  5238.5  377.33    5261  378.51  5269.6  379.93    5280  380.11  5311.1  378.93
  5352.5  374.45  5383.6  374.17  5456.2  377.44  5483.8   380.1  5580.6  384.27
#Mann= 3 ,-1 , 0
  4563.3     .05       0    4997     .03       0    5003     .05       0
#XS Ineff= 2 , 0
                         5327.95          377.14
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,62576   ,452,452,452
BEGIN DESCRIPTION:
PIN OAK CREEK 104.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3602599.56     10641810.18      3602999.61     10641860.19
      3603349.58     10642210.16
#Sta/Elev= 30
  4609.4  385.89  4639.7  384.41  4647.2  383.32  4690.1  380.76  4720.3  379.42
  4727.9  378.39  4732.9  378.59  4750.5  377.08  4780.8  375.62  4813.5  373.12
  4821.1  372.06  4851.3  370.38  4889.1  367.26  4911.8  366.43    4942  366.97
    4997   366.4  4999.8   365.9    5003   366.4    5010  366.86  5040.8  366.75
  5097.4  371.33  5196.4  375.58  5238.8  376.39  5309.5   375.8  5380.3  375.97
  5394.4  376.84    5451   378.2  5465.1   378.9  5479.2  380.57  5507.5  381.28
#Mann= 3 ,-1 , 0
  4609.4     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,62124   ,500,500,500
BEGIN DESCRIPTION:
PIN OAK CREEK 103.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3602549.63     10642510.18      3602949.61     10642310.19
      3603249.62     10642310.19
#Sta/Elev= 30
  4534.6  384.89  4632.4  379.92  4705.1  377.32  4744.2  374.39  4758.2  374.02
  4788.9  371.17  4825.3   369.3  4833.6  368.15  4839.2  368.35  4847.6  366.74
    4884  365.74  4892.3  364.71  4928.7  364.55  4937.1  365.43    4961  365.38
  4973.4  365.98  4991.8  365.44    4997   364.5  4999.8     364    5003   364.5
  5011.8  366.01    5025  365.67  5051.8   364.6  5081.8  364.82  5111.8  368.25
  5141.8  370.68  5171.8  374.43  5231.8  379.69  5251.8  380.89  5281.8  381.54
#Mann= 5 ,-1 , 0
  4534.6     .05       0    4961      .1       0    4997     .07       0
    5003      .1       0    5025     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,61624   ,429,429,429
BEGIN DESCRIPTION:
PIN OAK CREEK 102.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3602699.63     10642760.19      3602949.61     10642810.19
      3603349.57     10642610.21
#Sta/Elev= 30
  4748.3  382.55  4750.8  382.55  4758.5  378.88  4778.9  375.57  4799.3  374.26
  4819.7  371.94  4828.6  370.11  4860.5  367.19    4891  363.31  4901.2  363.15
  4911.4  364.27  4928.7   363.8    4993  363.06    4997  362.23  4999.8  361.73
    5003  362.23  5003.2  363.15  5032.1  363.22  5084.7  362.62  5101.1  363.27
    5129  362.23  5144.9  363.21  5168.1  364.19  5204.5  368.09  5240.8     370
  5279.9  373.46    5347  377.85    5361  377.99  5414.1  382.41  5450.4  384.36
#Mann= 8 ,-1 , 0
  4748.3     .05       0  4828.6      .1       0  4928.7     .05       0
    4997     .03       0    5003     .05       0  5032.1     .16       0
  5084.7      .1       0  5144.9     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,61195   ,470,470,470
BEGIN DESCRIPTION:
PIN OAK CREEK 101.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3602599.63     10642910.21      3602949.61     10643260.19
      3603749.64     10643360.19
#Sta/Elev= 30
  4535.5  386.55    4539  386.55  4549.6  383.32  4563.8  380.51  4577.9  380.66
    4592  382.24  4606.2  378.72  4634.5  384.57  4648.6  377.88  4676.9  375.18
  4761.7  371.47  4903.2   363.5    4988  362.89    4997   361.3  4999.8   360.8
    5003   361.3  5016.3  362.97  5038.2  362.24  5060.7   361.5    5101  362.71
  5262.2   361.3  5302.5  362.24    5435  362.13  5463.8  364.15  5471.4  366.47
  5504.1  370.31    5552  378.61    5625  385.93  5665.3   391.9  5836.7  403.21
#Mann= 5 ,-1 , 0
  4535.5     .05       0    4997     .03       0    5003     .05       0
  5038.2     .16       0    5435     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,60725   ,467,467,467
BEGIN DESCRIPTION:
PIN OAK CREEK 100.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3602499.56     10643660.18      3602899.61     10643710.19
      3603699.62     10643510.18
#Sta/Elev= 30
  4588.2  378.72  4608.4  376.95    4679  373.38  4729.3   369.1  4792.3  367.11
  4860.4  362.92  4872.9   363.1  4890.6  361.38  4923.5  360.94  4993.9  361.28
    4997   359.9  4999.8   359.4    5003   359.9  5055.8  361.35  5136.1  360.86
  5207.8  361.21  5249.1  362.94  5269.7  362.63  5310.9  364.91  5344.4  365.25
    5414   371.8  5468.1  374.92  5486.1  377.46  5545.4  382.32  5620.1  384.67
  5661.4  387.44  5669.1   389.2  5674.3  388.84  5710.3  393.08    5816  399.79
#Mann= 5 ,-1 , 0
  4588.2     .05       0  4923.5     .16       0    4997     .07       0
    5003     .16       0  5136.1     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,60258   ,436,436,436
BEGIN DESCRIPTION:
PIN OAK CREEK 99.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3601895.89     10644108.79      3603675.04     10644225.95
#Sta/Elev= 30
  4005.7  386.05  4039.5  385.17  4109.6  380.94  4159.8  375.08  4209.9  371.71
  4219.9  370.01    4270  368.91    4290  367.26  4450.4  367.28  4500.5  370.94
  4557.6  371.49  4640.8  367.46  4713.9  365.85  4771.1   362.6  4861.2  359.25
  4901.4  358.46  4951.5  359.75    4997  358.46  4999.8  357.96    5003  358.46
  5051.1  359.02  5091.8   360.2    5202  366.12  5332.3  374.35  5452.5  378.45
  5470.1  381.16  5582.8  386.53    5663  391.66  5777.7  395.85  5788.7  396.97
#Mann= 5 ,-1 , 0
  4005.7     .05       0  4861.2     .16       0    4997     .07       0
    5003     .16       0  5051.1     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,59822   ,446,446,446
BEGIN DESCRIPTION:
PIN OAK CREEK 98.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3602149.57      10644810.2      3602849.61     10644610.19
      3603249.66     10644610.19
#Sta/Elev= 30
  4254.1  379.67  4276.2  379.24  4304.8  375.77    4310  376.37  4337.3  373.98
  4343.8  372.29    4349  372.76  4382.8   369.9  4416.6  365.81  4421.8  366.49
  4450.4  361.95  4489.4  358.59  4523.2   358.5  4528.4  357.22    4795  357.22
  4831.7  359.15  4858.7  360.51  4918.3  357.35  4935.7   357.4  4960.1  359.46
  4971.8  357.72  4992.2  358.11    4997  357.22  4999.8  356.72    5003  357.22
  5012.2  358.93    5037  357.88  5132.2  360.23  5292.2  374.42  5382.2  379.96
#Mann= 7 ,-1 , 0
  4254.1     .05       0  4831.7     .16       0  4918.3     .05       0
  4935.7     .16       0    4997     .07       0    5003     .16       0
    5037     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,59376   ,522,522,522
BEGIN DESCRIPTION:
PIN OAK CREEK 97.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3602099.63     10644860.19      3602899.61     10645060.19
      3603399.62     10644760.18
#Sta/Elev= 30
  4151.8  381.72  4182.7  381.04    4193     379  4244.5  374.32  4252.3  372.93
  4306.4  368.58  4409.5  362.56  4540.9  358.31  4660.3  358.37  4761.3  359.56
  4829.5  359.58  4883.6   361.6  4917.1  360.84  4963.3  358.05  4973.8  356.15
    4997  355.65  4999.8  355.15    5003  355.65  5011.4     356  5026.9  359.31
  5042.5  361.48  5079.2  365.04    5093  365.71  5100.8  367.28  5137.7  369.14
  5201.9  369.73  5349.6   373.6  5466.2  379.88  5514.8  383.37  5559.5  385.14
#Mann= 7 ,-1 , 0
  4151.8     .05       0  4660.3      .1       0  4761.3     .05       0
  4963.3     .16       0    4997     .07       0    5003     .16       0
  5079.2     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,58854   ,204,204,204
BEGIN DESCRIPTION:
PIN OAK CREEK 96.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3601904.98      10645546.2      3605425.21     10645414.28
#Sta/Elev= 30
  3734.7  381.31  3859.4  378.82  3989.5  370.34  4169.6  364.17  4655.8  363.47
  4699.5   363.8  4798.7   367.5  4897.9   365.2  4920.2  362.17  4970.2  361.43
    4997  354.87  4999.8  354.37    5003  354.87  5030.2  354.87  5060.3  360.86
  5096.2   359.6  5120.3  357.33  5294.5  357.85  5393.6  358.18  5570.6  359.97
  5610.6  364.26  5940.9  365.69    6121  372.02  6385.2   376.7  6484.3  380.67
  6711.4  388.62  7021.6  390.05  7178.4  394.25  7216.9  395.46  7257.4  397.69
#Mann= 14 ,-1 , 0
  3734.7     .05       0  4655.8      .1       0  4699.5     .08       0
  4798.7     .05       0  4897.9     .12       0    4997     .07       0
    5003     .12       0  5096.2     .08       0  5294.5      .1       0
  5393.6     .05       0  6385.2     .16       0  6484.3     .05       0
  7178.4     .08       0  7216.9     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,58650   ,571,571,571
BEGIN DESCRIPTION:
PIN OAK CREEK 95.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3601967.55     10645726.76      3605439.71     10645650.37
#Sta/Elev= 30
  3804.8  380.19    3874  381.77  3936.9  379.13  4046.9  369.03  4176.9  364.13
  4663.7  357.88  4698.9  357.84  4777.1  357.09  4797.9   361.4  4957.1  359.69
    4996  354.91    4997  354.82  4999.8  354.32    5003  354.82  5095.1  360.15
  5194.1  360.65  5227.2  361.37  5241.1  365.63  5316.1  365.58  5370.6  364.04
  5407.2  366.22  5467.3   362.9  5617.3  364.14  6027.4   374.5  6157.4  374.55
  6427.5  382.84  6907.6  390.52  7007.6  386.16  7157.7  395.05  7277.8  395.95
#Mann= 11 ,-1 , 0
  3804.8     .05       0  4663.7     .08       0  4698.9     .05       0
  4797.9     .08       0    4996     .12       0    4997     .07       0
    5003     .12       0  5095.1      .1       0  5194.1     .05       0
  5316.1      .1       0  5370.6     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,58079   ,462,462,462
BEGIN DESCRIPTION:
PIN OAK CREEK 94.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3602647.62     10646625.75      3603275.25     10646031.97
      3603486.19     10645974.68      3604725.24     10645813.29
#Sta/Elev= 30
  4022.8  395.56  4098.8  393.44  4204.8  386.58  4275.6  379.72  4452.4  373.63
    4488  370.12    4594  364.09  4601.2  362.59  4622.3  362.96  4657.9  359.73
  4664.8  360.63  4693.1  359.32  4705.9  357.46    4928  356.85  4989.4  356.47
    4997  354.67  4999.8  354.17    5003  354.67  5015.7  357.29  5061.8   356.4
  5270.2  355.75  5364.1  363.66  5372.4  364.23  5408.7  363.87  5564.6  368.31
  5664.9  372.51  5765.2  375.09  5965.8   376.5    6021  377.43  6354.9  383.27
#Mann= 13 ,-1 , 0
  4022.8     .05       0  4705.9     .16       0    4928     .12       0
    4997     .07       0    5003     .12       0  5061.8     .16       0
  5364.1     .05       0  5372.4     .15       0  5564.6     .05       0
  5664.9     .16       0  5765.2     .05       0  5965.8     .16       0
    6021     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,57617   ,428,428,428
BEGIN DESCRIPTION:
PIN OAK CREEK 93.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3602799.63     10646660.18      3603399.61     10646410.19
      3604684.13     10645927.79
#Sta/Elev= 30
  4341.9  392.01  4462.7  381.12  4534.2  372.17  4727.7  360.02  4775.8  355.06
  4913.7  355.05  4976.3  355.82  4982.7  354.07    4997  354.07  4999.8  353.57
    5003  354.07  5022.1  354.07  5062.2  354.07  5067.5  355.97  5087.1  354.07
  5092.4  355.52  5098.7  354.07  5227.6  354.07  5236.7  354.07  5544.3  354.07
    5558  361.51  5568.7  364.45  5665.2  366.36  5715.1  370.17  5728.9  368.88
  5825.1  376.03  5976.6  379.54  6026.4  378.67  6252.3  381.24    6364  384.35
#Mann= 9 ,-1 , 0
  4341.9     .05       0  4727.7     .16       0  4913.7     .05       0
  4976.3     .16       0    4997     .07       0    5003     .16       0
  5022.1     .05       0  5227.6     .16       0  5236.7     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,57189   ,296,296,296
BEGIN DESCRIPTION:
PIN OAK CREEK 92.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3602639.81     10646857.49      3603598.17     10646781.97
      3603749.21     10646714.26      3604725.17     10645988.15
#Sta/Elev= 30
  3983.7  401.47  4043.7  399.16  4139.6  385.07    4154  385.51  4254.3  370.39
  4299.5  365.77  4383.2  363.37  4659.1  355.99  4758.7  354.07    4786  354.07
  4806.8  356.47  4816.1  354.07    4997  354.07  4999.8  353.57    5003  354.07
  5478.2  354.07  5507.4  358.86  5592.9  365.98  5707.6  365.47  5734.7  369.07
  5763.9  369.64  5778.5  368.06  5784.7  370.21  5813.9  372.01  5957.9  374.75
  5964.1  376.34  5978.7  375.18    6179   379.2  6243.6  384.58    6327  386.77
#Mann= 8 ,-1 , 0
  3983.7     .05       0  4299.5     .16       0  4383.2     .05       0
  4659.1     .16       0  4758.7     .07       0  4806.8     .05       0
    4997    .033       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,56893   ,119,119,119
BEGIN DESCRIPTION:
PIN OAK CREEK 91.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3602522.69     10647638.72      3603739.34     10647038.08
      3604929.84     10646461.75
#Sta/Elev= 30
  3545.7  383.78  3758.4  380.64  4170.3  365.54  4294.9  359.24    4328  358.21
  4407.4  357.13  4533.3  354.63  4632.5  354.07    4997  354.07  4999.8  353.57
    5003  354.07  5281.3  354.07  5298.3  357.07  5303.8  354.07  5343.5  358.47
    5349  354.83  5388.6  361.66  5394.2  359.11  5411.2  362.49  5416.8  360.08
  5501.5  364.77  5574.9  364.46  5625.6  371.07  5670.8  368.22  5851.4  374.35
  5880.5  367.98  5919.2  367.66  5964.4  368.87  5992.5  377.32  6225.2  379.67
#Mann= 9 ,-1 , 0
  3545.7     .05       0  4170.3     .16       0  4294.9     .05       0
    4328     .16       0  4407.4     .05       0  4533.3     .16       0
  4632.5     .05       0    4997    .033       0    5003     .05       0
#XS Ineff= 2 , 0
                         5847.16           374.4
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,56774   ,114,114,114
BEGIN DESCRIPTION:
Mapping XS ce79d390
END DESCRIPTION:
XS GIS Cut Line= 3
      3602605.13     10647755.92      3603820.02     10647130.21
      3604940.26     10646550.29
#Sta/Elev= 30
  3540.6  382.87  3635.6  383.57  3838.1  375.83  3950.6  374.37  4987.2  375.01
  4996.8  374.13    4997  366.97  4999.8  366.47    5003  366.97  5003.7  373.43
  5009.4  374.94    5048  372.85  5053.7   375.1  5070.2  372.97  5075.8  375.19
  5158.7  376.07  5396.6  373.96  5573.7  374.97  5634.4  372.73  5640.1  374.57
  5700.9  372.62  5706.5  374.61  5850.2   374.8  5872.3     368  5938.7  366.97
  5966.5  368.63  5988.6  376.03  6005.1  375.88  6027.3  380.56  6168.6  381.88
#Mann= 3 ,-1 , 0
  3540.6     .05       0    4997     .03       0    5003     .05       0
#XS Ineff= 2 , 0
                         5253.98          375.69
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,56660   ,776,776,776
BEGIN DESCRIPTION:
PIN OAK CREEK 90.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3602888.13      10647727.4      3605080.82     10646612.83
#Sta/Elev= 30
  3778.2  375.18  4223.3  358.68  4294.6  355.68  4449.7  353.23  4495.6  353.38
    4563   352.9  4676.2  352.51  4692.2  352.27    4958  353.18  4996.9  349.72
    4997  346.92  4999.8  346.42    5003  346.92  5013.6  346.92    5025  353.85
  5047.5  354.09  5085.9  362.52  5258.3  369.96    5531  367.02  5614.4  361.67
  5701.1  362.23  5747.9  362.81  5764.5  366.58  5770.1   363.2  5808.7  369.59
  5814.6     366  5843.9  373.23  5859.1  371.73  5888.8  375.84  6237.9  383.43
#Mann= 12 ,-1 , 0
  3778.2     .05       0  4223.3     .12       0  4294.6     .05       0
  4449.7     .12       0  4495.6     .05       0    4563     .12       0
  4676.2     .16       0  4692.2     .05       0    4997    .035       0
    5003     .05       0  5701.1     .08       0  5808.7     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55884   ,717,717,717
BEGIN DESCRIPTION:
PIN OAK CREEK 89.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603533.95     10648555.55       3604174.6     10647701.35
      3604789.15     10647237.83
#Sta/Elev= 30
  4033.2  362.69  4269.4  356.66  4304.8  354.53    4484  351.91    4534  348.88
  4954.8  349.98  4969.4  347.35    4984  338.35    4997  338.28  4999.8  337.78
    5003  338.28  5004.8  344.28    5034   350.2  5040.2  347.48  5048.6  349.06
  5069.4  347.95  5098.5  350.38  5126.9  348.96  5162.3  350.59  5247.7  350.74
  5320.2  349.46    5333  348.43  5341.3  346.23  5347.6  349.41  5355.9  349.88
  5426.7  350.64  5533.1  354.77  5605.7  355.39  5611.9  356.55  5870.7  365.78
#Mann= 3 ,-1 , 0
  4033.2     .05       0    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,55167   ,438,438,438
BEGIN DESCRIPTION:
PIN OAK CREEK 88.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3603699.59      10648610.2      3604399.61     10648110.19
      3604749.64     10647910.17
#Sta/Elev= 30
  4154.8  364.35  4254.4  360.13  4319.5  355.58  4476.8  348.92  4607.1  349.54
  4707.8  347.57  4743.5   348.8    4929  349.65  4952.7  347.74  4986.8   342.8
  4992.9  337.11    4997  336.52  4999.8  336.02    5003  336.52  5007.7  341.34
    5023  342.07  5028.7  344.73  5072.6  345.37    5082  344.36  5087.8  346.65
  5095.7   347.2  5103.6  345.87  5109.4  347.39  5125.2  344.07  5130.9   348.3
    5141   346.1  5146.8     349  5153.3  350.41    5361  362.16  5418.2  365.23
#Mann= 5 ,-1 , 0
  4154.8     .05       0  4952.7     .12       0    4997     .07       0
    5003     .12       0    5361     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,54729   ,1012,1012,1012
BEGIN DESCRIPTION:
PIN OAK CREEK 87.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3604597.62     10648963.01      3604692.82      10648160.6
       3604952.8     10647754.05
#Sta/Elev= 30
  4247.3  360.92  4421.3  351.84    4522  348.14  4590.2  347.47  4602.6  345.38
  4622.7  336.84  4632.8   336.7    4642   344.5    4647  343.47  4652.9  345.84
    4709  347.07  4731.3   347.3  4874.5  346.92  4900.2  342.64  4914.8  344.82
    4955   344.7  4976.1  342.47  4987.9  340.19    4997  336.68  4999.8  336.18
    5003  336.68  5015.5  343.02  5090.6  352.74  5132.9  361.32  5162.6  364.16
  5199.3  363.84  5312.8  364.17  5352.4  364.05  5479.1  365.82  5537.9  366.74
#Mann= 11 ,-1 , 0
  4247.3     .05       0  4590.2     .16       0    4709     .05       0
  4731.3     .16       0  4976.1     .12       0    4997     .07       0
    5003     .12       0  5199.3     .16       0  5312.8     .12       0
  5352.4     .16       0  5479.1     .12       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,53717   ,721,721,721
BEGIN DESCRIPTION:
PIN OAK CREEK 86.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605054.81     10649112.86      3605023.57     10647754.32
#Sta/Elev= 30
  4622.1  364.95  4704.8  361.01  4764.8  354.16  4814.8  350.27  4824.8  348.59
  4874.8     349  4964.9  355.36  4974.9  348.56  4984.9   343.2  4994.9  333.04
    4997  333.04  4999.8  332.54    5003  333.04  5004.9  333.28  5014.9  341.13
  5023.6  342.17  5034.9  342.57  5054.9  346.96  5234.9  346.55    5305  347.23
    5325   346.1    5345  347.39    5365  346.23    5385  347.98    5485  349.76
    5515  353.78    5545   356.1  5685.7  363.14  5755.1  366.12    5981  367.88
#Mann= 5 ,-1 , 0
  4622.1     .05       0    4997     .03       0    5003     .05       0
  5023.6     .12       0  5685.7     .16       0
#XS Ineff= 2 , 0
          4915.8  352.13
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,52996   ,521,521,521
BEGIN DESCRIPTION:
PIN OAK CREEK 85.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605268.35     10649180.51      3605351.68      10648482.6
       3605424.6     10647466.98
#Sta/Elev= 30
  4376.4  365.95  4396.9  365.73  4487.5  359.78  4527.8   358.6  4628.5  350.23
  4739.3  337.93  4779.6  337.39  4799.7  338.22  4829.9  341.79  4890.3  345.73
  4940.7  346.79  4968.6  344.97    4997  332.53  4999.8  332.03    5003  332.53
  5011.2  335.95  5017.9  342.23  5031.3  345.66  5303.6  346.38  5401.6  351.84
  5452.6  353.61  5502.8  351.51  5522.8  352.74  5538.5  355.46  5543.5  352.73
    5593  360.31  5656.7  364.71  5923.8  370.45    5974  369.82  6097.5  373.06
#Mann= 7 ,-1 , 0
  4376.4     .05       0  4968.6     .12       0    4997     .07       0
    5003     .12       0  5303.6     .16       0  5401.6     .05       0
  5656.7     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,52475   ,150,150,150
BEGIN DESCRIPTION:
PIN OAK CREEK 84.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605149.72     10649668.86      3606441.36     10647460.57
#Sta/Elev= 30
  3649.9   370.5  4190.7  360.68  4343.5  352.32  4431.2  340.98  4474.2  341.47
  4505.6  336.76  4511.4  341.06  4548.5  338.98  4671.7  352.84  4923.3  342.84
  4949.3  341.57  4970.8  334.44  4992.3  335.13    4997  330.42  4999.8  329.92
    5003  330.42  5029.5  340.39  5066.7  344.37    5139  341.99  5264.2  346.23
  5301.4  343.01  5367.6   347.6  5393.9  348.05  5477.4   351.7  5548.3  361.32
  5600.5  360.92  5803.8  384.09  5884.3  386.27  6032.7  381.93  6208.2  392.04
#Mann= 7 ,-1 , 0
  3649.9     .05       0  4923.3     .16       0    4997     .07       0
    5003     .16       0    5139     .05       0  5367.6     .12       0
  5393.9     .05       0
#XS Ineff= 2 , 0
         4613.07  347.03
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,52325   ,751,751,751
BEGIN DESCRIPTION:
PIN OAK CREEK 83.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605264.29     10649726.17      3606587.21     10647549.09
#Sta/Elev= 30
  3656.3  365.77  3831.6  357.99  4137.8   353.7  4370.3  342.42  4407.1  344.38
  4428.5  340.73  4443.9  343.52  4449.8  340.52  4480.7  341.61  4486.6  337.66
  4523.4  342.51  4581.5  342.15  4646.2  351.72  4750.1  352.43  4930.4  343.09
  4988.5  334.58    4997   330.2  4999.8   329.7    5003   330.2  5040.8  341.33
  5062.1  342.72    5360  346.33  5450.1  356.02    5477  360.06  5514.2  358.42
  5600.9  366.58  5759.8  389.42  5891.6  391.84  6060.1  384.58  6203.8     396
#Mann= 5 ,-1 , 0
  3656.3     .05       0    4997     .04       0    5003     .05       0
  5450.1     .08       0  5514.2     .05       0
#XS Ineff= 2 , 0
         4665.91  354.54
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,51574   ,355,355,355
BEGIN DESCRIPTION:
PIN OAK CREEK 82.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605307.72     10649825.54       3606671.4     10648792.15
#Sta/Elev= 30
  3952.3  362.71  4071.3   357.5  4200.3  347.96  4335.5  340.68  4350.1  337.94
  4414.6   335.5  4707.5   335.6  4793.2  342.97  4857.7   343.5  4913.9  343.26
  4957.5  340.97    4971  342.19  4984.6  340.03  4993.9  334.32    4997  329.68
  4999.8  329.18    5003  329.68  5007.4  329.68  5013.7  334.43  5028.3  339.89
  5178.1  343.81  5207.2  347.57  5235.5  346.51  5248.8  347.23  5298.7  355.75
  5352.5  352.52    5366  353.83  5477.6  368.99  5542.1  379.51  5663.3  389.98
#Mann= 7 ,-1 , 0
  3952.3     .05       0  4993.9     .16       0    4997     .07       0
    5003     .16       0  5235.5     .05       0  5352.5     .08       0
    5366     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,51219   ,353,353,353
BEGIN DESCRIPTION:
PIN OAK CREEK 81.0
END DESCRIPTION:
XS GIS Cut Line= 3
       3605245.2     10650085.97      3606276.45     10649455.76
      3606771.24     10649117.22
#Sta/Elev= 30
  3900.8  361.94  4075.4  356.49  4105.2  353.71  4286.4  344.42  4361.8  337.06
  4381.2   335.5  4515.4   335.5  4686.9   335.5    4745   341.5  4787.6  342.65
  4831.8  346.15  4861.1  346.19  4913.3  345.18    4956  341.82    4997  328.17
  4999.8  327.67    5003  328.17  5007.6  329.06  5019.9  337.54  5042.8  342.89
  5050.8   343.3  5056.6  341.61  5252.3   342.8  5288.2  345.28    5318  353.09
  5380.9   349.9  5431.7  354.38  5533.3  368.76  5634.2  380.63  5708.9  385.46
#Mann= 5 ,-1 , 0
  3900.8     .05       0  4361.8     .16       0  4515.4     .05       0
    4997     .03       0    5003     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,50866   ,314,314,314
BEGIN DESCRIPTION:
PIN OAK CREEK 80.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605235.97     10650426.22      3607063.19     10649362.87
#Sta/Elev= 30
  3607.1  361.76  3709.1  359.24  3826.6  350.67  3935.3  347.72  4120.3   335.5
  4419.9   335.5  4478.6  342.98  4601.9  351.11  4719.4  340.55  4725.2  337.27
  4772.3  337.57  4814.6  338.14  4858.4  344.71  4885.7  345.81  4907.2  340.38
  4988.1  333.43    4997  327.54  4999.8  327.04    5003  327.54  5011.3  329.03
  5018.9  339.07  5114.9   345.2  5123.4  347.76  5200.9  350.94  5231.1  347.48
  5306.9  357.42  5345.9  362.17  5478.9   376.6  5559.2  379.84  5721.2   380.7
#Mann= 7 ,-1 , 0
  3607.1     .05       0  4772.3     .16       0    4997     .07       0
    5003     .16       0  5123.4     .05       0  5306.9     .08       0
  5345.9     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,50552   ,545,545,545
BEGIN DESCRIPTION:
PIN OAK CREEK 79.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605283.71     10650799.48      3607235.68     10649567.57
#Sta/Elev= 30
  3376.9  364.81  3387.4  366.17  3525.8  361.72  3779.2  344.95  3858.1  337.16
  3909.8   335.5    4317   335.5  4374.6  340.88  4432.3  348.96  4532.3  351.41
  4605.3  348.46  4684.6  339.01  4799.6  337.53  4954.8  338.77  4991.2  331.65
    4997  327.42  4999.8  326.92    5003  327.42  5012.4  328.14  5027.5  338.71
  5133.6  339.63  5157.6   341.3  5170.1  345.79  5210.5  346.24  5211.2  346.27
  5279.6  353.86  5352.5  365.26  5467.9  376.38    5562   379.7  5685.1  378.76
#Mann= 7 ,-1 , 0
  3376.9     .05       0  4799.6     .12       0    4997     .07       0
    5003     .12       0  5133.6     .05       0  5210.5     .08       0
  5211.2     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,50007   ,472,472,472
BEGIN DESCRIPTION:
PIN OAK CREEK 78.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605699.65     10651060.17      3606699.61     10650460.19
      3607249.62     10649860.18
#Sta/Elev= 30
  3812.1  361.47  3994.8  355.12  4286.3  348.16  4381.5  343.49  4476.8   335.5
  4544.1   335.5  4605.7   335.5  4768.3  335.58  4826.6  340.79  4912.2  339.61
  4943.3  340.83  4970.5  336.69  4975.3  332.91  4985.3   332.3    4997   328.8
  4999.8   328.3    5003   328.8  5056.3  336.45    5063  338.66    5113  339.58
  5119.8  342.09  5133.9  342.88  5148.1  341.08  5154.9  343.62    5204  343.76
  5211.6  342.39  5300.2  344.85  5381.8  347.85  5565.6  361.93  5792.2  374.66
#Mann= 7 ,-1 , 0
  3812.1     .05       0  4544.1      .1       0  4605.7     .05       0
    4997     .03       0    5003     .05       0    5204     .08       0
  5300.2     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,49535   ,319,319,319
BEGIN DESCRIPTION:
PIN OAK CREEK 77.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605846.46     10651351.44      3607685.73     10650440.49
#Sta/Elev= 30
  3980.6  359.43    4065  358.38    4118  355.06  4154.7  355.72  4226.2  347.32
  4238.4  347.11  4363.5  347.18  4440.7  353.28    4508  349.58  4564.4  349.53
  4642.5  352.23  4765.8  347.63  4805.1  348.99  4849.9  346.91  4932.7  337.95
  4990.1  329.78    4997  327.41  4999.8  326.91    5003  327.41  5021.9  331.35
  5051.7  332.74  5066.6  336.29    5119   342.4  5169.4  339.77  5320.8  339.16
  5455.4  349.24  5724.5  355.22  5870.2  362.09  5976.7  363.03  6033.1  361.43
#Mann= 5 ,-1 , 0
  3980.6     .05       0  4226.2     .08       0  4238.4     .05       0
    4997     .03       0    5003     .05       0
#XS Ineff= 2 , 0
                         5121.02          342.42
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,49216   ,436,436,436
BEGIN DESCRIPTION:
PIN OAK CREEK 76.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3605950.63     10651737.73      3607772.86     10650674.76
#Sta/Elev= 30
  3870.3  356.05  4174.5  352.54  4291.9  347.25  4297.7  349.08  4313.4  349.33
  4334.9  346.97  4473.8  347.25  4526.7  351.28  4671.5  351.41  4773.2  349.35
  4810.4  351.73  4876.3  343.39  4906.3  337.81  4970.8  330.95  4992.3  330.04
    4997   326.8  4999.8   326.3    5003   326.8  5029.5  330.97  5045.2  330.18
  5073.1  336.14  5096.3  338.36  5109.7  342.31  5125.4  343.61  5323.1  337.82
  5360.3  338.93  5424.8  344.42  5696.9  348.02  5871.9  359.82  5979.9  360.48
#Mann= 3 ,-1 , 0
  3870.3     .05       0    4997     .03       0    5003     .05       0
#XS Ineff= 2 , 0
                         5200.28          341.87
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,48780   ,563,563,563
BEGIN DESCRIPTION:
PIN OAK CREEK 75.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3605985.35     10652041.55      3607248.41       10651499.
       3607912.2     10650934.99
#Sta/Elev= 30
  3776.2  357.69  4075.6  353.77  4222.3  347.64  4655.4  347.32    4793  344.23
  4860.1  345.99  4901.8  341.29  4930.8  336.19  4945.4  335.18  4977.9     330
  4983.3  328.92  4988.9  326.17    4997  325.26  4999.8  324.76    5003  325.26
  5006.9  328.71  5021.6  329.41  5111.9  341.14  5119.5  343.14  5130.1  343.51
  5165.6  341.51  5342.4  337.51    5371  334.55  5406.1  334.52  5625.7  343.68
    5718  345.54  5832.3  350.37  5910.2   351.9  5966.2  355.63  6021.9   354.5
#Mann= 3 ,-1 , 0
  3776.2     .05       0    4997     .03       0    5003     .05       0
#XS Ineff= 2 , 0
                         5276.14          339.32
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,48217   ,498,498,498
BEGIN DESCRIPTION:
PIN OAK CREEK 74.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606358.64     10652314.97      3607534.87     10651967.75
      3609018.49     10651004.69
#Sta/Elev= 30
  3890.8  354.83  4280.7  351.54  4329.7  348.65  4548.7   345.1  4590.4  340.08
  4629.3  342.51  4839.5  337.47  4861.5  339.54  4949.9  330.98    4997  321.86
  4999.8  321.36    5003  321.86  5088.3  336.33  5155.7  334.48  5191.9  337.64
    5213  334.43    5273  334.23  5400.2  331.03  5761.2  336.78  6064.7  339.31
  6100.9  341.94  6146.3   337.4  6390.9   337.4    6412   342.1  6499.6   341.6
  6725.4  357.43  6774.5  361.92  6795.6  361.71  6808.7  359.12    6886   365.8
#Mann= 7 ,-1 , 0
  3890.8     .05       0    4997     .03       0    5003     .05       0
    5273     .16       0  5761.2     .05       0  6725.4     .08       0
  6808.7     .05       0
#XS Ineff= 2 , 0
                         5196.31          336.96
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,47719   ,301,301,301
BEGIN DESCRIPTION:
PIN OAK CREEK 73.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3606688.48     10652466.88      3607539.21      10652501.6
       3609043.8     10651664.75
#Sta/Elev= 30
  4017.2  349.65    4465  338.76  4548.8  341.96  4608.8  335.73  4648.9  334.01
  4914.9  332.56    4988  324.09    4997  321.78  4999.8  321.28    5003  321.78
  5052.2   329.5  5103.8  334.35  5171.1  334.21  5200.9  337.77  5327.5  328.97
  5376.9  328.86  5495.9  333.82  5604.5  334.44  5612.9  331.86  5663.4  333.59
  5685.7  331.86  5835.9  331.86  6118.4  336.68  6162.6  337.35  6207.9  343.32
  6297.5   344.8  6365.2  348.67  6417.8  351.73  6487.4  355.57  6590.3   365.5
#Mann= 11 ,-1 , 0
  4017.2     .05       0    4988     .16       0    4997     .07       0
    5003     .16       0  5103.8     .05       0  5327.5     .16       0
  5663.4     .05       0  5835.9     .16       0  6118.4     .05       0
  6365.2     .08       0  6417.8     .05       0
#XS Ineff= 2 , 0
                          5237.5          334.08
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,47418   ,668,668,668
BEGIN DESCRIPTION:
PIN OAK CREEK 72.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3606560.85     10653128.38      3609371.66      10652144.6
#Sta/Elev= 30
  3668.3  349.05    4504  332.18  4906.6  329.45  4946.5  324.11  4982.8   323.6
    4997  319.74  4999.8  319.24    5003  319.74  5015.1  321.58    5028  323.89
  5070.6  323.81  5118.5  330.71  5139.7  331.06  5171.4   337.1  5194.7  334.53
  5225.8  325.82  5277.2  328.69  5319.2  327.43  5514.9  331.13  5706.3  335.93
  5799.4  331.96  5943.9  332.61  6029.6  340.69  6155.8  342.74  6326.3  355.11
  6503.1  372.16  6538.2  370.22  6559.4  374.43  6609.4  378.05  6646.3  380.88
#Mann= 9 ,-1 , 0
  3668.3     .05       0    4997     .03       0    5003     .05       0
  5015.1     .16       0    5028     .05       0  5319.2     .16       0
  5514.9     .05       0  6503.1     .08       0  6609.4     .05       0
#XS Ineff= 2 , 0
                         5200.28          333.13
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
