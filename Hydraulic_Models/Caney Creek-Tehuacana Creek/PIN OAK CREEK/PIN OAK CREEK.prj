HEC-RAS study PIN OAK CREEK.prj: PIN OAK CREEK Base Level Engineering

--- PIN OAK CREEK.g02 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,18088   ,893,893,893
BEGIN DESCRIPTION:
PIN OAK CREEK 20.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3607640.59     10672073.94      3609713.04     10671292.71
#Sta/Elev= 30
  3803.7  323.58    3919  319.89  3969.3  312.62  4024.3  307.67  4054.6  303.41
    4115  299.54  4164.7  292.69    4170  293.44  4200.2  291.11  4225.1  287.11
  4230.4  287.71  4280.2  281.43  4403.2  277.71  4505.8  274.88  4754.6  274.91
  4978.2  276.57  4987.2  265.86    4997  264.49  4999.8  263.99    5003  264.49
  5010.3  272.44  5017.4  275.66  5095.2  275.52  5117.1  274.58  5288.1  279.68
  5418.3  290.63  5662.2  310.03  5699.6  314.18  5870.1  325.42  6018.5  337.99
#Mann= 8 ,-1 , 0
  3803.7     .05       0    3919     .16       0  4403.2     .05       0
  4754.6     .12       0    4997     .07       0    5003     .12       0
  5095.2     .05       0  5418.3     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,17195   ,1574,1574,1574
BEGIN DESCRIPTION:
PIN OAK CREEK 19.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608449.63     10673010.16      3608949.61     10672210.19
      3609749.64     10671610.17
#Sta/Elev= 30
  4077.8     311    4122  309.62  4212.7  300.58  4331.9  288.37  4438.4  281.75
  4666.8  274.51  4786.1  273.79  4817.9  273.99  4861.4  274.05  4867.9   269.8
  4876.7  272.21    4971  275.31  4985.8  269.34  4992.3  263.66    4997  263.66
  4999.8  263.16    5003  263.66  5007.6  268.53  5018.2  275.23    5146  273.24
  5151.1  273.29  5273.4  275.09  5306.5  275.05  5394.3  279.26  5463.9   283.4
  5599.3   297.3  5713.9  306.21  5849.3  319.36  5957.6  332.39  6021.2   337.3
#Mann= 12 ,-1 , 0
  4077.8     .05       0  4212.7     .16       0  4438.4     .05       0
  4786.1     .16       0  4817.9     .12       0    4997     .07       0
    5003     .12       0    5146     .05       0  5151.1     .12       0
  5273.4     .16       0  5306.5     .05       0  5394.3     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,15621   ,1134,1134,1134
BEGIN DESCRIPTION:
PIN OAK CREEK 17.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3608439.21     10673396.85      3610800.34     10672445.46
#Sta/Elev= 30
  3898.1  315.94  3970.5  314.42  4103.4  309.89  4157.3  304.59  4178.8  296.77
  4201.3  299.75  4279.2  292.42  4308.8   287.2  4332.9   287.4  4361.8  283.86
  4547.8  273.29    4733  271.17  4935.5  272.87  4977.4  272.77    4997  262.32
  4999.8  261.82    5003  262.32  5019.8  266.38  5025.8  273.37    5128  272.44
  5342.6  272.07    5488  275.39  5642.9  283.52    5724  290.01  5748.1  295.92
  5813.2  302.78  5921.6   310.6  6248.9  338.64    6423  356.56  6443.7  358.42
#Mann= 12 ,-1 , 0
  3898.1     .05       0  3970.5     .16       0  4361.8     .05       0
  4935.5     .12       0    4997     .07       0    5003     .12       0
    5128     .16       0    5488     .12       0  5642.9     .16       0
  5813.2     .12       0  5921.6     .16       0    6423     .12       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,14487   ,529,529,529
BEGIN DESCRIPTION:
PIN OAK CREEK 15.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608999.59      10674260.2      3609799.61     10673660.19
      3610599.61     10672860.18
#Sta/Elev= 30
  3975.4  297.19  4047.3  291.25    4249  281.38    4289  280.54  4397.3  273.48
  4632.7  267.88  4855.6  271.73  4918.1  272.83    4979   271.9  4989.6  266.63
    4997  260.95  4999.8  260.45    5003  260.95  5017.8   262.4    5032  268.24
  5046.1  271.16  5060.3  268.53  5088.6  271.17  5094.3  270.29  5116.8  269.16
  5147.1  272.32  5187.6  272.31  5280.5  275.47  5406.2  276.06  5611.8  283.95
  5668.4  288.23  5710.4  294.32  5795.7  301.98  5922.9   308.7  6106.8  324.89
#Mann= 10 ,-1 , 0
  3975.4     .16       0    4249     .05       0  4855.6     .12       0
    4997     .07       0    5003     .12       0  5094.3     .16       0
  5147.1     .05       0  5280.5     .16       0  5406.2     .12       0
  5710.4     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,13958   ,536,536,536
BEGIN DESCRIPTION:
PIN OAK CREEK 14.0
END DESCRIPTION:
XS GIS Cut Line= 3
       3609099.6     10674360.19      3609899.61     10674060.19
      3610499.64     10673860.18
#Sta/Elev= 30
  4175.5  291.88  4187.9  291.33  4336.6  280.28  4393.8  277.69  4416.7  274.96
  4463.9  272.99  4634.8  268.57  4752.2  267.59  4837.7  268.28  4874.2  269.92
  4954.2   271.4  4976.5  270.52  4984.5  266.61  4989.9  261.05    4997  261.05
  4999.8  260.55    5003  261.05  5014.8  269.34  5027.2  270.94  5082.6  271.08
  5103.7  269.72  5135.3  270.61  5162.7  270.18    5204  270.09  5251.3   271.3
  5293.4  274.99    5304  276.82  5409.4   285.1  5525.3  298.28  5662.4  309.24
#Mann= 8 ,-1 , 0
  4175.5     .05       0  4187.9     .16       0  4393.8     .05       0
  4954.2     .12       0    4997     .07       0    5003     .12       0
  5162.7     .05       0    5204     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,13422   ,894,894,894
BEGIN DESCRIPTION:
PIN OAK CREEK 13.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608904.46     10674382.97      3610244.75     10674382.97
      3611321.15     10674320.47
#Sta/Elev= 30
    3905  308.08  3960.1  299.51  3990.1  300.28  4020.1  296.44  4090.1  293.69
  4148.2  289.04  4349.8  272.32  4490.1   268.2  4600.1  267.62  4893.8  271.24
  4950.1  270.12  4980.1  271.34    4997  261.43  4999.8  260.93    5003  261.43
  5010.1  262.06  5030.1  270.51  5100.1  269.43  5248.4  272.64  5310.3  274.03
  5500.6  283.12    5771  297.95  5861.2     305  5980.4  316.82  6043.2  321.13
  6101.6  324.14  6142.6  323.63  6181.7  321.26  6244.5  320.94  6323.5  318.03
#Mann= 10 ,-1 , 0
    3905     .05       0  4148.2     .16       0  4349.8     .05       0
  4893.8     .12       0    4997     .07       0    5003     .12       0
  5248.4     .16       0  5980.4     .12       0  6043.2     .16       0
  6142.6     .12       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,12528   ,519,519,519
BEGIN DESCRIPTION:
PIN OAK CREEK 12.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608949.65     10674510.21      3609749.61     10674860.19
      3610549.57     10675510.16
#Sta/Elev= 30
  4116.9  304.31  4211.5  295.19  4306.4  288.04  4442.8  278.61    4488  276.59
  4527.3  271.78  4556.2  270.66  4695.4  268.86  4761.4   269.6  4802.8  269.79
  4934.7  268.95  4968.2  269.51  4975.6  267.73  4981.1  262.82  4987.3  259.91
    4997  259.19  4999.8  258.69    5003  259.19  5011.6  262.26  5018.1   269.6
  5331.2  267.68  5395.2   267.5  5564.4  273.44    5673  279.07  5717.8  285.38
  5836.1  296.13    5865     300  5881.2   300.4  5959.7  308.95  6020.8  315.23
#Mann= 15 ,-1 , 0
  4116.9     .16       0  4211.5     .05       0  4306.4     .16       0
  4442.8     .05       0  4761.4     .08       0  4802.8     .05       0
  4934.7     .12       0    4997     .07       0    5003     .12       0
  5331.2     .16       0  5564.4     .05       0  5717.8     .16       0
  5836.1     .05       0  5881.2     .12       0  5959.7     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,12009   ,607,607,607
BEGIN DESCRIPTION:
PIN OAK CREEK 11.0
END DESCRIPTION:
XS GIS Cut Line= 2
      3608660.55     10675022.63       3610500.8      10675612.9
#Sta/Elev= 30
  4010.9  317.09  4072.9  319.29  4125.4  312.52  4242.4  300.37  4546.9  277.33
    4605  271.66  4755.5  266.54  4912.8   266.7  4944.6  266.69  4976.1   269.2
  4986.6   266.8    4997  258.76  4999.8  258.26    5003  258.76  5007.6  258.76
  5015.5  261.49    5034  267.84  5039.3  266.49  5060.1  268.52  5081.1  268.61
  5144.1  266.24  5263.4   268.8  5426.4  274.92  5543.5  279.68  5585.2  280.94
  5749.6   294.4  5813.8  299.69  5868.7  306.32  5926.1  309.74  5943.5  310.34
#Mann= 13 ,-1 , 0
  4010.9     .16       0  4242.4     .12       0    4605     .05       0
  4912.8     .07       0    4997     .07       0    5003     .07       0
  5015.5     .12       0  5263.4     .16       0  5426.4     .05       0
  5543.5     .16       0  5749.6     .05       0  5813.8     .16       0
  5926.1     .12       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,11402   ,711,711,711
BEGIN DESCRIPTION:
PIN OAK CREEK 10.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608266.74     10675886.19      3609649.61     10675810.19
      3610449.63     10675910.19
#Sta/Elev= 30
  3613.7  320.87  3706.7  321.57  3756.8  320.54    3813  317.09    3897  307.95
    3954   304.3  3987.6  302.22  4017.2  298.41  4057.2  296.03  4277.6  276.26
  4356.8  271.72  4711.4  267.52  4748.3  266.41  4808.4  268.28  4968.6  268.39
  4988.6  257.77    4997   257.6  4999.8   257.1    5003   257.6  5008.7  266.71
  5018.8  268.32  5089.4  266.22  5228.1  271.53  5290.9  275.04  5391.7   277.5
  5472.3  282.51  5492.5   282.5  5557.3  288.95  5681.4  300.59  5804.9  315.63
#Mann= 8 ,-1 , 0
  3613.7     .05       0    3954      .1       0  3987.6     .16       0
  4711.4     .12       0    4997     .07       0    5003     .12       0
  5228.1     .16       0  5557.3     .12       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10691   ,558,558,558
BEGIN DESCRIPTION:
PIN OAK CREEK 9.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608949.59      10676660.2      3609649.61     10676310.19
      3610449.57      10676010.2
#Sta/Elev= 30
  4207.2  314.81  4233.5  313.22  4254.5  311.28    4333   303.2  4372.1  300.91
  4394.5  297.58  4461.6   292.3  4497.9   291.2  4506.3  289.13  4542.6  285.69
  4659.1  276.21  4824.9  265.21  4923.9  266.43  4981.5  266.77  4987.1  264.62
  4992.5  264.62    4997  257.73  4999.8  257.23    5003  257.73  5011.2  257.92
  5021.9  266.68  5035.2  268.07  5182.1  265.43  5207.8  266.25  5280.3  265.44
  5341.3  267.85  5506.6  279.99  5517.6  280.16  5804.2  310.74  5844.2  317.33
#Mann= 11 ,-1 , 0
  4207.2     .12       0  4233.5     .16       0  4254.5     .05       0
  4659.1     .16       0  4923.9     .12       0    4997     .07       0
    5003     .12       0  5207.8     .16       0  5280.3     .12       0
  5341.3     .16       0  5506.6     .12       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10133   ,261,261,261
BEGIN DESCRIPTION:
PIN OAK CREEK 8.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608949.58     10676760.19      3609749.61     10676760.19
       3610549.6      10676010.2
#Sta/Elev= 30
    4185  317.95    4221   315.7    4325  305.21    4345  300.89    4610  280.94
    4685  276.96    4705  273.71    4725  275.13    4745  272.62    4755  273.14
    4875  265.87    4975  266.83  4982.5  263.86  4988.5  263.86  4992.1  256.08
    4997  255.71  4999.8  255.21    5003  255.71  5013.1  255.74  5020.4  263.57
  5034.6  266.53  5239.8  263.95  5402.4  267.59  5621.7  280.65  5749.2  293.87
  5793.3  297.12  5897.7  309.56  5932.9  312.24  6025.2  324.82  6081.6  330.91
#Mann= 7 ,-1 , 0
    4185     .12       0    4221     .16       0    4610     .12       0
    4685     .16       0    4997     .07       0    5003     .16       0
  5793.3     .12       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,9872    ,636,636,636
BEGIN DESCRIPTION:
PIN OAK CREEK 7.0
END DESCRIPTION:
XS GIS Cut Line= 2
       3609139.7     10677086.27      3610875.21     10676871.07
#Sta/Elev= 30
  4319.6   297.4  4471.7  288.59  4569.3  282.84  4662.1  279.61  4695.8  277.22
  4814.3  269.48  4853.6  266.31    4893  264.94    4974  266.48  4984.6     264
    4997  254.55  4999.8  254.05    5003  254.55  5014.8  257.42  5034.9   266.3
  5086.9  265.71  5286.9  263.24  5453.7  269.83  5626.5   280.7  5649.5  281.14
  5712.5  286.47  5760.5  289.18  5841.1  297.37  5950.3  305.82  5982.1  311.25
  6012.4  314.23  6031.2  317.55  6036.2  316.96  6062.8  321.21  6068.4  323.16
#Mann= 9 ,-1 , 0
  4319.6     .12       0  4471.7     .16       0  4695.8     .05       0
  4814.3     .16       0    4997     .07       0    5003     .16       0
  5086.9     .05       0  5453.7     .16       0  5649.5     .12       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,9236    ,847,847,847
BEGIN DESCRIPTION:
PIN OAK CREEK 6.0
END DESCRIPTION:
XS GIS Cut Line= 3
       3609143.2     10677596.68      3610535.57     10677541.13
      3610843.66     10677856.13
#Sta/Elev= 30
  4192.5     283  4208.9  281.04    4259   278.8    4349  270.96  4439.1  264.97
  4579.2  262.22  4759.4  262.55  4852.6  263.97  4983.5  265.29  4989.5  258.94
    4997  254.04  4999.8  253.54    5003  254.04  5009.6  261.46  5019.6  265.62
  5043.5  264.94  5169.7  262.44  5325.4  266.58  5522.2  274.37  5609.4  278.59
    5864   297.3  5892.3  299.97  5906.4  303.27  5920.5  305.17  5934.6   308.4
  5948.7  309.89  5962.9  313.61  5989.4   317.8  6012.5  321.45  6026.6  321.67
#Mann= 8 ,-1 , 0
  4192.5     .05       0  4852.6     .16       0    4997     .07       0
    5003     .16       0  5043.5     .05       0  5325.4     .16       0
  5522.2     .12       0  5989.4     .16       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,8389    ,540,540,540
BEGIN DESCRIPTION:
PIN OAK CREEK 5.0
END DESCRIPTION:
XS GIS Cut Line= 3
       3608799.6     10677810.18      3609549.61     10678110.19
       3610349.6     10678210.19
#Sta/Elev= 30
  4157.8  295.62  4292.2  287.28  4405.5  280.69  4573.8  266.75  4696.3  260.44
  4771.7  260.08  4943.7  263.76  4975.7  264.63  4985.7  257.87    4997   253.8
  4999.8   253.3    5003   253.8    5016  264.11  5157.1  261.74  5217.5  264.07
  5245.2  267.31  5257.8  267.18  5288.1   261.6  5321.1  261.31  5388.9  261.16
  5429.2  263.43  5492.2  268.39  5519.6  272.69    5540  276.33  5580.3  278.75
  5610.6  284.41  5620.6  284.82    5671  295.45  5697.5  298.42  5771.8  306.96
#Mann= 8 ,-1 , 0
  4157.8     .12       0  4292.2     .05       0  4943.7     .16       0
    4997     .07       0    5003     .16       0  5321.1     .05       0
  5519.6     .16       0  5697.5     .05       0
#XS Ineff= 2 , 0
                         5257.95           267.2
Permanent Ineff=
       F       F
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,7849    ,548,548,548
BEGIN DESCRIPTION:
PIN OAK CREEK 4.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608799.64     10677860.22      3609449.61     10678560.19
      3610249.59     10678910.18
#Sta/Elev= 30
  4049.3  295.02    4100  293.64  4188.5  288.48  4389.1  272.61  4601.1  260.67
  4686.2  259.95  4749.7  261.83  4863.1   260.8  4942.4  263.29  4976.4   263.8
  4983.2  256.01  4990.6  253.68    4997  253.68  4999.8  253.18    5003  253.68
  5007.2  254.88  5013.5  264.01  5073.6  262.47  5124.6   263.2  5170.2  260.38
  5287.1  261.94    5316  261.58  5321.4  260.09  5367.2   261.1    5434  262.72
  5659.4  274.75    5712  280.54  5717.5  279.54  5740.9   281.7  5877.7  298.91
#Mann= 9 ,-1 , 0
  4049.3     .12       0    4100     .16       0  4188.5     .05       0
  4942.4     .16       0    4997     .07       0    5003     .16       0
  5073.6     .05       0  5367.2     .16       0    5434     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,7301    ,467,467,467
BEGIN DESCRIPTION:
PIN OAK CREEK 3.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3608899.62     10678560.19      3609649.61     10678960.19
      3610399.62     10678960.19
#Sta/Elev= 30
  4151.7  283.79  4187.5  282.29    4299  266.27  4351.8  261.85  4565.7  260.94
  4587.7  261.83  4669.8  260.36  4675.5  261.93  4697.5  260.59  4713.8  262.45
  4777.2  262.34  4867.5  261.56  4971.6  262.66  4987.9   253.4    4997  252.27
  4999.8  251.77    5003  252.27  5011.7  253.33  5021.7  262.94    5025  262.77
  5111.7  260.33  5341.7  272.41  5431.7  278.98  5491.7  285.49  5521.7  290.68
  5561.7  295.37  5601.7  302.82  5631.7  310.75  5691.7  319.61  5751.7  326.35
#Mann= 5 ,-1 , 0
  4151.7     .05       0  4777.2     .16       0    4997     .07       0
    5003     .16       0    5025     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,6834    ,1853,1853,1853
BEGIN DESCRIPTION:
PIN OAK CREEK 2.0
END DESCRIPTION:
XS GIS Cut Line= 3
      3607842.19     10678595.52      3609222.43     10679163.25
      3610366.48     10679168.45
#Sta/Elev= 30
  3220.1  304.46  3244.9  306.06  3452.8  304.05  3511.5   302.8  3567.6  299.35
  3636.7  294.36  3790.4  287.26  3796.7  285.21  3814.5  284.23  3959.8  273.07
  4025.1  269.54  4210.5  265.68    4615  259.99  4902.8  261.05  4969.7  262.31
  4979.7  257.46    4997  252.16  4999.8  251.66    5003  252.16  5009.7  254.25
  5019.7   262.3  5173.3  260.93  5289.7  259.37  5319.7  260.34  5449.7   272.7
  5529.7  282.42  5549.7  286.45  5629.7  295.05  5739.7  301.48  5856.6  312.42
#Mann= 10 ,-1 , 0
  3220.1     .12       0  3567.6     .16       0  3814.5      .1       0
  3959.8     .16       0  4025.1      .1       0  4210.5     .05       0
  4902.8     .16       0    4997     .07       0    5003     .16       0
  5173.3     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4981    ,0,0,0
BEGIN DESCRIPTION:
PIN OAK CREEK 1.0
END DESCRIPTION:
XS GIS Cut Line= 4
      3608297.35      10678920.4      3609845.98     10679989.85
      3610207.09     10679941.24      3610609.86     10679295.43
#Sta/Elev= 30
  2901.8  286.15  2986.9  281.28  3009.1  280.38  3477.5  261.71  3828.8  258.66
  3938.7  258.87    4290  260.11  4845.7  258.26  4971.4  260.39  4989.3  255.95
    4997  248.69  4999.8  248.19    5003  248.69  5009.5  251.54  5019.6  259.45
  5074.5  258.79  5208.4  257.64  5259.1  259.87  5478.6   278.6  5600.1  297.88
  5673.2   307.2  5709.8  309.56  5731.1  313.76  5746.4  313.69  5752.3  316.49
    5783     315  5788.9  318.34  5804.2  316.49  5856.1  317.92  5909.3  322.51
#Mann= 10 ,-1 , 0
  2901.8     .16       0  2986.9     .05       0  3009.1     .16       0
  3477.5     .05       0  3828.8     .16       0  3938.7     .05       0
  4845.7     .16       0    4997     .07       0    5003     .16       0
  5074.5     .05       0
Bank Sta=4997,5003
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
